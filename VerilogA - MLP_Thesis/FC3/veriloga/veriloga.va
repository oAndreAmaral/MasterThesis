// VerilogA for MLP_Thesis, FC3, veriloga

`include "constants.vams"
`include "disciplines.vams"


// FC3 -> From and input of 250 to 250 neurons
module FC3_Layer(x,y);

  parameter real W20[0:249] = {-0.036551,-0.000830,0.033860,0.044002,-0.047819,0.005486,0.050901,-0.024225,0.020973,-0.073428,-0.041155,0.044968,0.027205,-0.024221,0.063622,-0.027233,-0.005836,-0.022579,0.074987,-0.033721,0.008423,-0.076569,-0.042093,-0.007339,0.054062,0.051670,0.003628,0.040809,-0.016954,-0.048989,-0.011548,-0.013746,-0.049851,0.017131,0.086741,0.060782,-0.064179,0.011358,-0.002559,0.042005,-0.007665,-0.044771,0.050607,0.052273,-0.008486,0.002915,-0.013397,-0.016384,0.032219,0.039649,-0.003089,-0.037877,0.054566,0.025188,0.018241,-0.023723,0.011020,-0.015236,0.013782,0.023770,0.006355,-0.039252,-0.031149,-0.030650,-0.033073,-0.065746,-0.013042,0.027490,-0.063787,0.039203,-0.052911,-0.039700,-0.024643,0.040771,-0.059860,0.064518,-0.008658,0.005610,0.022200,0.061635,-0.029531,0.004851,-0.021643,0.060493,-0.072858,0.038908,-0.079395,-0.045389,0.007609,0.005518,0.060114,0.057183,0.007046,0.026307,0.047361,0.048758,-0.038623,0.057520,-0.051002,0.002738,0.019314,-0.020174,0.070444,0.026333,-0.050454,-0.002001,0.014786,0.011478,-0.068034,-0.032309,0.022845,0.012030,0.014454,-0.014479,-0.005378,-0.061345,-0.084048,-0.007573,-0.013945,-0.021040,0.081698,-0.058115,-0.024031,0.057560,0.042574,0.043825,-0.016354,0.072831,0.074915,0.016244,-0.021185,0.067163,0.020227,-0.052350,-0.003013,0.024980,-0.013560,0.005266,0.009700,0.016405,0.050741,0.047417,-0.027912,0.009777,-0.017599,-0.073066,-0.027924,0.068457,0.053781,0.023235,-0.052322,-0.067509,0.063313,0.016629,-0.077982,0.032950,0.050800,0.043881,-0.012487,0.006700,-0.014774,-0.034234,0.002704,0.025662,-0.064606,-0.041171,-0.007296,0.074731,-0.046426,0.035450,-0.063349,0.017777,-0.061214,0.023469,0.048245,-0.043885,-0.021565,-0.040689,0.020777,0.014615,0.000117,0.020767,-0.058048,-0.029195,0.031320,-0.015015,-0.008720,-0.002079,0.019903,0.015955,-0.043926,-0.092082,0.043315,0.022933,0.080287,-0.026211,0.048969,0.060761,-0.043704,0.047168,0.002500,0.025449,0.030779,0.053192,-0.025587,0.050361,-0.073352,0.065636,-0.016672,-0.033908,-0.066811,0.018939,-0.037588,0.061439,-0.007724,0.026869,-0.043159,-0.009250,0.042117,0.029922,0.036402,0.033301,-0.016586,0.044860,-0.038007,0.029091,-0.058551,-0.059017,0.038502,-0.042987,0.032128,0.002187,-0.027160,0.033156,0.014485,0.003092,-0.005424,0.003164,-0.024066,0.001204,-0.053517,-0.015615,-0.055338,0.013868,0.007579,-0.015108,0.002788,0.064549,-0.018336,0.007941};
  parameter real W21[0:249] = {-0.048926,-0.014761,-0.010557,-0.021667,0.007325,0.043617,-0.040060,-0.037246,-0.044608,0.035143,-0.056498,-0.027803,0.022080,0.066184,-0.043242,-0.005169,0.050599,-0.024324,0.031661,0.049985,-0.028956,-0.040372,0.050569,0.034776,-0.031397,0.033205,0.055475,-0.028718,-0.036534,0.063787,-0.062298,0.028347,-0.038419,0.061068,0.042190,0.008129,-0.012662,0.043596,-0.017150,-0.053019,0.050430,0.055101,0.024025,-0.002553,-0.005476,-0.021181,-0.060716,0.005379,-0.059710,-0.051809,-0.022669,-0.002100,-0.050097,0.049175,0.041433,-0.005137,0.011232,-0.020857,0.022850,0.028536,-0.065481,-0.051289,0.043172,-0.022422,0.053353,-0.057991,-0.020187,-0.057003,0.054444,-0.023097,-0.032370,-0.028628,-0.055839,-0.051817,0.023043,-0.049201,0.005927,-0.040039,-0.031234,-0.007923,0.035962,-0.013999,-0.045896,-0.061662,0.012399,-0.003721,0.063442,-0.046892,-0.039791,0.054397,-0.049419,0.023601,-0.009347,0.036925,0.049162,-0.067247,0.039206,0.035215,-0.054974,0.036517,-0.049704,0.059483,-0.037061,0.000167,-0.003909,0.022898,0.055242,-0.001563,-0.024799,-0.053861,0.046182,0.053632,0.013236,0.036737,-0.059357,-0.026724,-0.004197,0.038446,0.001979,0.027874,0.032034,-0.048926,0.004350,-0.033445,0.010450,0.010646,-0.051181,-0.027733,0.027933,-0.003118,0.061261,0.041104,0.017609,0.002494,-0.023749,-0.056060,-0.014459,0.008989,0.026098,0.020143,0.041581,-0.008325,-0.028071,0.060709,-0.046560,-0.031060,0.064905,0.014674,-0.031585,0.021309,0.006526,0.051901,0.000178,0.058235,0.000624,0.023608,0.002102,-0.032929,-0.035260,0.050001,-0.017622,-0.029188,0.042810,-0.032485,-0.026904,-0.020591,-0.051049,0.009582,-0.066135,0.012803,0.043375,0.055901,0.017084,0.043388,0.005819,-0.048137,0.054770,0.019891,-0.015066,-0.012370,0.012773,0.047510,0.011141,0.062140,0.065794,0.011542,0.021469,0.022760,0.026080,-0.006413,-0.006645,0.059256,-0.034781,-0.013822,-0.042902,0.007934,-0.038645,-0.044598,0.007734,-0.000339,-0.040694,-0.012968,-0.041048,0.059281,0.052119,-0.022421,-0.012247,0.026607,-0.018266,0.000661,-0.025582,-0.023529,0.018800,0.004955,-0.050606,0.007662,0.042787,-0.046282,0.051928,-0.030694,-0.004834,-0.047911,0.047509,-0.026087,-0.044744,-0.023801,0.063431,-0.009843,0.032498,0.062273,0.027946,-0.040842,0.002692,0.047441,-0.002597,0.039009,-0.004413,0.061950,0.033033,0.036386,-0.001951,-0.001828,-0.039317,0.064744,-0.022023,-0.009582,0.054078,-0.046307,-0.053508,-0.053973};
  parameter real W22[0:249] = {-0.044188,0.020531,-0.005845,-0.000981,0.021170,-0.029917,0.016108,0.006206,-0.050631,0.017806,-0.036443,0.005075,0.009441,-0.045131,-0.059922,-0.057420,0.055179,-0.055579,-0.016745,0.016285,0.000642,0.005971,0.055482,-0.004178,0.036992,0.017701,-0.037130,0.020611,-0.011712,0.033752,0.027821,-0.026116,-0.029887,-0.012615,-0.018612,-0.038599,0.029375,-0.021789,-0.017927,-0.005240,-0.042018,0.026414,0.007738,0.057336,-0.006328,0.052558,0.005584,0.020947,0.047602,-0.059611,-0.055537,-0.034931,0.060602,0.039314,0.058824,0.054111,-0.057228,0.033352,-0.038200,0.047667,-0.041651,0.045233,0.040259,0.048342,0.002759,0.006694,-0.003440,-0.006909,0.015606,-0.052736,-0.023148,0.011271,-0.027015,0.038581,-0.039243,0.041309,0.042972,0.001465,-0.027338,0.051721,0.049009,-0.055304,-0.035793,0.018829,-0.043794,-0.030886,-0.062868,0.026699,0.045228,0.022486,0.037563,-0.009415,0.042461,0.007822,0.028966,-0.038307,-0.008303,0.047442,0.028799,0.018604,-0.028669,-0.047063,-0.015764,0.052712,0.051023,-0.023682,0.011520,0.025156,-0.058859,0.038571,-0.061403,0.058389,-0.059318,0.056375,0.045576,-0.041605,0.048281,0.006383,0.031461,0.049151,-0.000281,-0.041563,-0.036613,0.042837,0.033724,-0.017912,0.019173,0.024218,-0.040966,-0.055299,0.041790,-0.015380,-0.019735,0.001405,0.059380,-0.056166,0.052463,-0.043768,-0.034766,0.013592,0.034220,-0.021028,0.036923,-0.035953,-0.013218,-0.024479,-0.020680,-0.031067,0.058649,0.036780,-0.033621,0.044940,-0.018977,-0.015077,0.061253,0.021505,0.024728,0.054547,0.028478,-0.056956,-0.034897,0.010715,-0.059485,-0.015337,-0.039543,-0.023321,-0.033438,0.039984,-0.058023,0.066531,0.022976,-0.047313,0.019140,-0.001870,-0.056073,-0.027317,0.029410,-0.015517,-0.027884,0.038597,0.033646,-0.035178,0.044001,-0.008892,0.009242,-0.057933,0.023373,0.029407,-0.038630,-0.042513,-0.052768,0.018718,-0.002313,-0.024790,0.027919,0.031692,0.055235,-0.042587,0.041171,-0.006905,-0.029605,-0.021994,0.002301,-0.043242,-0.000514,-0.017689,-0.058541,0.008280,-0.002101,-0.038353,-0.052232,0.040591,0.064541,-0.029026,0.055884,0.049859,-0.013075,-0.019281,-0.059462,-0.037620,0.045602,-0.060835,-0.007423,-0.013865,-0.059492,-0.039554,-0.060962,-0.003771,0.043000,0.005307,-0.008446,-0.052749,-0.060889,-0.006319,-0.026512,0.060787,-0.061740,0.054678,0.048289,0.053371,-0.001520,0.050107,-0.041141,0.007116,-0.018736,0.000570,0.031183,-0.017837,0.045377,-0.058153};
  parameter real W23[0:249] = {0.056635,-0.047335,0.036153,-0.049114,0.022782,0.035193,0.015007,-0.034279,0.009698,0.023243,-0.028560,0.026853,-0.028188,0.026424,-0.008089,-0.002030,-0.016743,-0.032655,0.054117,-0.055858,0.040993,-0.034210,0.055240,-0.003447,0.019758,-0.004730,-0.029869,-0.010726,0.042615,-0.002001,0.001724,-0.016767,0.037980,-0.061861,0.060166,0.003334,0.048749,0.010865,-0.058430,-0.045027,0.045605,-0.051290,0.057044,0.021804,0.049782,0.001855,-0.038052,-0.041735,-0.025294,0.020524,0.037522,-0.030673,0.034244,0.024831,-0.019294,-0.015471,0.047661,0.044445,-0.002072,-0.059430,0.040071,0.044644,0.046709,-0.050260,0.061507,0.025934,0.018906,-0.026180,0.012787,0.039167,0.005612,0.056334,-0.027180,0.018467,-0.043616,0.042428,-0.028245,0.017821,0.059980,-0.056629,-0.026829,0.027707,-0.023363,-0.033618,0.033123,0.012533,0.053299,-0.063850,-0.032306,-0.005725,-0.042169,0.012605,0.056938,0.002378,0.022101,0.003007,-0.043738,0.050251,0.016600,-0.012127,-0.054009,0.011611,-0.045087,0.049454,0.006814,0.009676,0.033571,0.016530,0.038319,0.042825,0.047169,-0.033164,-0.031934,0.028423,0.018269,0.006463,-0.049468,0.014058,-0.057999,0.009507,0.037263,-0.037194,-0.054292,0.053019,0.011530,0.046815,0.027620,0.049812,-0.025097,-0.026495,0.034608,0.037588,-0.044720,-0.057504,0.065249,-0.021609,-0.026536,-0.011535,-0.041708,0.044481,0.020103,0.033490,0.028643,0.061334,-0.061153,-0.057760,-0.044208,0.052695,0.020357,-0.062344,-0.041233,-0.033735,0.035499,0.008062,0.029010,-0.024326,-0.016816,0.037735,0.045109,-0.047063,0.013958,0.017361,0.044204,-0.051024,-0.002331,-0.049349,0.011177,-0.033140,-0.004067,0.062362,0.025087,0.026097,0.049110,0.048708,0.036862,0.063285,-0.026373,-0.007165,-0.035923,-0.050971,-0.008182,0.046304,0.026680,-0.001081,0.050316,0.045789,-0.037764,-0.010878,-0.060357,0.030168,0.047178,-0.048155,-0.006010,-0.015417,0.026329,-0.027518,0.032029,-0.001935,-0.008360,0.000142,0.030894,-0.054104,-0.033278,-0.040815,-0.028529,0.065374,0.056209,-0.049260,0.000950,-0.035449,0.022881,-0.029742,-0.012122,-0.027600,0.055049,-0.055664,-0.011083,0.004181,-0.029700,-0.006727,0.019752,-0.027163,0.024866,-0.003155,0.046711,0.033214,-0.019766,-0.036459,-0.053413,-0.020241,-0.035193,0.043327,-0.059185,-0.014343,-0.055604,0.020486,-0.034177,-0.028630,-0.049451,-0.056110,0.044985,-0.003283,-0.008146,-0.031957,0.019434,-0.045893,-0.052986,0.024721,0.003610,-0.027213};
  parameter real W24[0:249] = {0.002965,-0.027853,0.053953,-0.001754,-0.058752,0.003515,0.029795,-0.042919,0.008688,-0.019488,-0.044019,0.046941,0.006970,-0.030124,0.005773,0.043169,0.057982,0.015401,-0.072329,-0.016824,-0.002312,-0.031036,-0.049876,-0.035203,0.049302,-0.001850,0.017393,0.025246,-0.018102,0.048665,0.052584,0.024965,-0.042352,-0.006743,0.007938,0.009461,0.010412,0.028601,-0.049919,-0.030324,-0.042953,-0.029393,-0.051512,-0.038819,0.051631,-0.009382,0.053538,0.051342,-0.008587,-0.030502,-0.046101,-0.053407,-0.014573,0.015514,-0.003965,0.051111,-0.042142,-0.055468,0.019191,-0.063345,-0.057510,-0.014361,-0.018613,0.014813,-0.031406,-0.045191,0.022883,0.010612,0.067215,0.004710,0.005168,0.049674,-0.045216,0.026278,0.043082,-0.003451,0.026468,0.001952,0.001419,0.007881,0.019372,0.016699,-0.049830,-0.037219,-0.030601,0.032664,0.022334,-0.005559,-0.055651,0.007032,-0.055720,0.048456,-0.041866,0.005341,-0.017093,-0.002874,-0.038295,0.049830,-0.047152,-0.038329,-0.005925,-0.015070,-0.060801,-0.010732,-0.050131,0.022434,0.059176,0.052488,-0.042179,0.057208,0.040725,0.007958,0.011663,0.044065,-0.045732,0.001591,0.013147,0.052467,0.044823,-0.058968,0.002556,0.026323,0.004351,-0.044778,-0.046000,-0.025842,-0.032296,-0.024032,-0.041898,0.003068,-0.035160,-0.021413,-0.037847,-0.051096,-0.059730,0.013942,0.047949,0.046082,-0.057289,0.027913,-0.061146,-0.046128,-0.041711,0.009933,-0.017457,0.011655,-0.045009,-0.058424,-0.057008,-0.058212,-0.000547,-0.000185,-0.036945,0.061081,0.038330,0.044516,0.005928,0.007677,0.045744,-0.059781,-0.015073,0.000384,0.002785,0.053717,0.009545,-0.056484,-0.001957,0.057359,0.001365,-0.032111,-0.031272,-0.024975,0.050545,0.047727,0.000150,0.038558,-0.029391,0.041089,-0.020477,-0.005126,-0.004395,-0.027234,0.047959,0.023800,0.009338,-0.039280,-0.038056,-0.024145,-0.052976,-0.034851,-0.058431,-0.007263,0.021174,-0.029161,-0.046829,0.029288,0.035025,0.010195,0.060450,0.052092,0.030414,0.007432,-0.014685,0.036719,0.053586,-0.056032,-0.062349,0.015628,-0.005854,0.005392,-0.023808,-0.029365,-0.043792,-0.061238,0.006293,-0.023591,-0.034389,0.025063,-0.012490,0.025789,-0.011891,-0.030875,-0.052072,-0.052994,0.034922,-0.028107,0.003252,0.006641,0.003850,-0.052286,-0.009826,-0.055605,0.050857,0.050183,-0.005984,0.027987,0.042737,0.061014,-0.017416,0.037752,0.038022,-0.012353,-0.030183,-0.056999,0.062188,0.016572,-0.013677,-0.065378,0.013369,-0.050045};
  parameter real W25[0:249] = {-0.027791,-0.029185,0.041459,0.042648,0.044028,-0.048057,-0.061220,0.039030,0.018248,-0.039996,-0.020773,-0.016822,-0.007828,-0.015891,0.052228,0.053871,0.004217,-0.008215,-0.054546,0.021972,-0.046605,0.011322,-0.034904,-0.009621,0.029788,-0.047927,0.037492,0.051466,-0.045949,0.004162,0.046636,-0.021842,0.046753,-0.025745,0.072132,0.020317,-0.014682,0.008590,-0.044039,0.014615,0.038900,0.062257,-0.040127,-0.023915,0.046968,-0.001308,-0.020809,0.036108,0.076596,-0.041841,-0.056995,0.048348,0.078461,0.034605,-0.001645,-0.020649,-0.060228,-0.021929,-0.015833,-0.008482,0.059704,0.000288,0.028465,0.050482,0.030199,0.009773,-0.057913,-0.023021,-0.029784,0.032178,-0.011726,-0.027697,-0.014624,0.054477,0.005573,0.020941,-0.037104,0.013070,-0.041315,-0.034218,-0.048808,0.049474,-0.035021,0.035932,0.014629,-0.059341,0.000372,0.051357,-0.004553,-0.040459,0.054091,-0.047148,0.020192,0.026344,0.014026,-0.037167,-0.041189,0.026129,0.002286,0.041201,-0.028471,-0.029772,0.019628,0.049004,0.057727,-0.065420,0.035675,-0.015002,0.055438,0.027993,-0.060945,0.059649,-0.007135,0.032497,-0.035275,0.045308,-0.014041,-0.041024,-0.054677,0.062544,0.016257,-0.018240,0.051576,-0.050140,-0.023625,-0.052357,0.034683,0.035402,0.037865,0.050835,0.008476,0.049163,-0.042643,0.010994,-0.025654,0.004867,-0.007787,0.005654,0.030815,0.052749,-0.023630,-0.059121,-0.006098,-0.015912,-0.067419,0.013848,-0.024761,0.067409,0.038039,-0.060778,0.000803,0.003682,0.057957,-0.014297,-0.057155,-0.046998,0.004037,0.070740,-0.007044,-0.015194,-0.014762,0.047502,0.023828,-0.015192,0.020082,-0.030990,-0.015795,0.008825,-0.063737,-0.049173,-0.061309,0.033032,0.040987,0.020172,0.063753,0.050321,-0.020741,-0.009112,-0.041571,-0.041177,0.058839,0.030200,-0.040753,0.049502,0.015513,0.012711,0.034405,-0.003782,0.042068,-0.019617,-0.021402,-0.019442,0.049256,0.001920,0.078391,0.030513,0.013777,0.031824,-0.017042,0.045128,0.049009,-0.056811,0.040754,-0.058705,-0.058037,-0.033676,-0.033142,0.055261,-0.003782,0.013549,0.045969,0.016348,-0.002148,-0.047634,-0.008373,0.065037,-0.064579,-0.029269,0.050127,-0.006715,0.037934,0.022081,-0.059289,-0.003356,0.050598,-0.052262,-0.032497,0.007916,0.041293,0.032774,0.056258,0.041600,0.001723,0.064666,-0.046732,-0.035733,0.008852,0.032274,-0.033797,-0.060602,-0.038547,-0.052145,0.028525,0.059955,-0.060985,-0.031588,-0.013556,0.026305,0.018054,-0.034002};
  parameter real W26[0:249] = {0.036231,0.057751,0.050400,-0.031039,0.059187,0.057675,-0.047227,-0.058744,-0.051567,-0.050978,0.043123,-0.019916,-0.015566,0.050228,0.027465,0.060087,0.028921,-0.012874,-0.041830,0.016802,0.050406,-0.003749,-0.001703,0.007395,0.032604,-0.021169,-0.015252,0.038815,-0.039889,0.003752,-0.029630,0.041914,0.018788,0.025690,-0.030584,-0.008144,0.038890,0.053945,-0.052604,0.064733,0.024716,-0.005303,0.018622,0.046474,0.031947,-0.047808,0.025899,-0.026355,-0.035473,0.001501,-0.032712,-0.033075,0.009992,0.042757,0.005177,0.047850,0.035310,-0.002227,0.010338,-0.035272,-0.063352,0.030096,-0.030803,-0.030533,0.037702,0.043642,0.051592,-0.001613,0.030426,0.020631,-0.027755,0.023260,-0.040403,0.053468,0.013845,-0.055766,-0.031991,0.026697,0.041748,-0.020389,-0.037183,0.056518,0.012155,0.032767,0.015350,0.001074,0.009816,0.006653,-0.006919,0.037555,0.007549,0.060480,-0.039181,0.020491,0.063375,-0.048998,0.038464,0.002277,-0.050923,0.046068,0.026545,0.053095,0.027805,-0.048090,0.022404,0.040574,-0.008256,-0.041747,0.051512,-0.048055,-0.013487,-0.029531,-0.019935,-0.035079,0.016543,-0.018031,-0.035805,-0.033210,-0.054844,0.007275,-0.055537,-0.001117,0.013443,-0.018009,-0.059678,0.027888,0.048781,-0.057440,-0.001642,-0.012164,0.029076,-0.028029,0.041318,0.026605,-0.049586,0.020254,-0.004345,0.062972,0.049071,0.040035,-0.044635,-0.006991,0.030866,0.002574,-0.049620,-0.036489,0.008258,-0.055529,0.048724,0.025268,0.062453,0.054197,0.047305,0.033658,0.022671,-0.048821,-0.063185,0.040773,-0.027576,0.022916,-0.042817,0.042300,0.014885,-0.026411,-0.020015,-0.044478,0.067246,0.006529,-0.001159,-0.004008,0.017454,-0.011186,0.060613,0.000536,0.025868,-0.041020,0.006133,-0.025813,0.027419,-0.041778,-0.062633,0.048586,0.022253,-0.008170,-0.048136,-0.006876,0.032656,-0.015356,-0.055699,0.011630,-0.022838,-0.004748,-0.050398,0.021763,0.027600,-0.059209,-0.061993,-0.045551,-0.028273,-0.061688,0.021610,0.041892,0.053731,-0.023549,0.043857,0.025822,0.017937,-0.039568,-0.053073,-0.052897,0.026464,0.008252,-0.047087,-0.006253,-0.049774,-0.011255,0.046696,0.011339,-0.062021,-0.049227,0.049780,0.020838,0.037575,0.053292,0.046369,0.041477,0.023820,0.060855,-0.040122,-0.055400,0.030464,0.016913,0.048342,0.044146,-0.031052,-0.049435,0.060565,0.013054,-0.048354,-0.015065,0.026417,-0.025456,0.019142,0.033433,0.045055,0.027225,0.010413,-0.048579,0.010852,0.018626};
  parameter real W27[0:249] = {-0.014364,-0.002542,0.032973,-0.028475,0.024015,0.030375,-0.047416,-0.002133,0.035680,0.010385,0.008478,0.011014,-0.058190,-0.042009,0.053732,0.007580,-0.039704,-0.029807,-0.048257,-0.015609,-0.043249,-0.044771,-0.030858,0.051755,-0.034610,-0.039037,0.000057,0.048318,0.043591,-0.034479,-0.049516,0.036814,-0.046377,0.054623,-0.014754,0.014315,-0.018579,-0.019600,0.021827,0.014548,-0.026571,0.025427,0.041670,-0.022846,-0.012532,0.050353,0.025580,0.023598,0.034861,-0.045790,-0.012160,-0.020954,0.050697,0.034664,0.015581,-0.055838,-0.022220,0.019940,0.029815,0.001749,-0.007517,-0.002220,0.039659,0.003474,0.041863,0.043924,-0.020944,0.050963,-0.061471,-0.048685,0.022687,-0.047362,0.045036,-0.041816,0.016460,0.049573,-0.009501,0.038341,0.033327,0.015281,0.016331,0.005452,0.025504,0.060822,0.044871,-0.034407,-0.062328,0.033101,-0.027671,0.022068,-0.027262,0.042773,-0.019878,-0.044234,0.021153,0.059440,-0.003000,-0.058586,-0.019282,0.029405,-0.054968,-0.049190,-0.014507,-0.047943,-0.016794,0.005940,0.055825,-0.016553,-0.021309,-0.022621,-0.057512,0.021214,0.037707,-0.011412,-0.050077,-0.023454,0.034755,-0.004689,-0.008259,-0.065287,0.004317,-0.037241,-0.046731,0.023671,-0.050991,0.013072,0.033227,0.017963,0.012246,-0.065218,0.031489,-0.049947,-0.033130,-0.041815,-0.038792,-0.034854,0.038271,-0.037274,0.000792,0.017649,-0.048018,-0.005772,-0.023826,-0.003211,0.041553,0.004605,-0.058312,0.017015,-0.034461,-0.000935,-0.030569,-0.056029,0.000845,-0.010257,-0.051158,-0.047247,0.042260,-0.005360,0.044692,0.061373,-0.032907,0.012082,-0.014281,-0.035143,0.003280,0.022612,0.008928,-0.002011,-0.053101,0.052921,-0.057412,-0.002887,0.032460,0.005149,-0.033743,-0.052745,0.030853,-0.018585,0.032183,-0.011931,0.034442,0.047517,-0.059438,0.001999,0.037929,-0.061120,-0.023412,-0.025855,0.037424,0.007521,0.036812,-0.051405,-0.032666,-0.048526,-0.022477,0.054988,0.057708,-0.031363,0.028743,-0.064430,-0.030644,-0.002350,-0.029864,0.053582,0.005956,0.044465,-0.070471,0.032195,0.064286,0.015432,0.009086,-0.042628,-0.023443,0.029193,0.048770,-0.027212,0.012487,-0.010793,0.001169,0.031525,-0.046448,-0.006991,-0.008591,-0.057683,0.057976,0.006208,0.045306,-0.017108,0.028645,-0.032384,0.001733,0.010479,-0.002297,-0.044788,-0.045740,0.033776,-0.027039,-0.042938,0.003565,0.027064,-0.011322,0.003314,-0.023610,-0.020258,0.045452,-0.060578,-0.015692,0.022424,0.061863,-0.054553};
  parameter real W28[0:249] = {0.027580,0.045193,-0.003149,0.036382,-0.048556,-0.049226,0.061315,-0.062786,-0.014986,-0.012324,-0.002695,0.004467,0.004278,-0.055156,0.001988,-0.038345,-0.018919,0.070669,0.062399,0.029179,0.003484,-0.040487,-0.010556,0.058784,-0.025692,0.022271,-0.025385,-0.047613,0.014347,-0.000444,-0.049942,-0.050878,-0.056472,0.022928,0.044553,-0.054736,-0.047736,-0.003371,0.056737,-0.053290,0.000198,-0.030348,-0.039681,0.006444,0.029278,-0.037062,0.058210,0.029463,0.001487,0.021809,-0.018317,0.003973,0.047149,-0.037327,0.025760,-0.020015,0.032355,0.064569,-0.037893,-0.003541,0.046833,-0.021312,-0.064680,0.010700,0.060537,0.055464,-0.046888,-0.007343,-0.032241,-0.057779,0.011608,-0.058454,-0.050247,0.052389,-0.064800,-0.016483,-0.037018,-0.054329,-0.052704,-0.055958,0.027417,0.017138,0.059280,0.066854,0.022467,-0.007476,0.027870,-0.017898,0.046074,0.061096,0.061805,0.011584,0.049811,0.014725,-0.036836,0.008569,-0.016052,0.004474,-0.051575,-0.047974,0.027864,-0.037290,-0.022141,-0.038961,-0.018504,0.000289,-0.079356,-0.046008,-0.007964,0.041939,-0.042792,0.002514,0.041077,-0.039111,-0.005513,-0.060120,-0.024381,0.014321,-0.011016,0.053338,0.055125,-0.059449,0.023937,0.042024,0.062269,-0.060796,0.000049,0.026724,0.056819,0.009175,-0.048078,0.021284,0.023097,-0.060805,0.070215,0.050758,-0.014378,-0.068059,-0.040398,0.011152,-0.058285,-0.014304,0.031446,0.047039,-0.033662,0.051738,-0.036070,-0.040502,0.046316,-0.025551,0.013860,-0.022426,0.039495,-0.009480,0.008540,-0.006048,0.034975,0.043814,0.025158,0.044683,-0.003023,-0.013573,0.008030,-0.051635,-0.022492,-0.056828,-0.042779,-0.005599,-0.037454,0.041068,0.026958,0.052336,0.021356,0.040746,0.051762,-0.040095,0.040383,0.059556,-0.042730,0.038893,-0.010557,-0.009134,-0.015781,-0.053052,0.044727,0.007916,-0.035928,-0.046779,-0.008375,-0.013939,-0.050885,0.017008,-0.008444,-0.027400,0.033567,-0.005536,-0.054513,0.064417,0.051088,-0.055900,-0.015351,-0.023769,0.021982,0.045641,-0.022279,-0.013951,0.056575,0.035590,0.041231,-0.046506,-0.035165,-0.029694,0.020738,0.024925,-0.038310,-0.015657,-0.035715,-0.007893,-0.016484,0.019335,0.031433,-0.018068,-0.019571,-0.015290,0.043396,-0.053414,0.060122,0.059370,0.010112,-0.005259,-0.006372,-0.003483,-0.049353,-0.016201,0.049453,-0.009762,0.056699,-0.028829,0.056598,0.018061,-0.039785,0.019018,0.042860,0.004672,0.003412,-0.054925,0.040112,-0.019215,-0.007602,0.013945};
  parameter real W29[0:249] = {-0.042034,-0.031248,0.009294,-0.029216,0.030038,-0.048027,-0.051883,-0.044820,-0.014331,-0.000202,-0.029581,0.034496,-0.018412,0.022642,0.029433,-0.055128,-0.001049,0.051182,-0.044836,-0.001616,0.044707,-0.028589,0.000738,0.056383,0.058371,0.001005,-0.008768,0.015892,-0.027247,0.020343,-0.003329,-0.034092,0.006104,-0.047781,-0.014774,-0.011236,-0.040329,-0.034396,0.021870,-0.048085,-0.058876,0.033329,0.032105,0.028005,-0.006332,0.026133,0.061824,-0.033010,0.004261,0.044776,-0.025799,-0.018601,0.028743,0.057437,-0.023659,0.030007,-0.011373,0.051245,-0.056119,0.049948,0.062882,0.055389,-0.004086,-0.024273,0.000251,-0.005798,0.038445,0.048657,-0.022548,0.052412,-0.061184,0.012835,-0.054647,-0.053761,0.060804,0.055451,0.052734,0.042919,0.067101,-0.041875,0.036498,0.004387,0.005763,-0.048192,-0.003588,-0.013236,0.054603,0.027000,-0.047633,-0.010698,0.047599,-0.012461,-0.034379,-0.033780,-0.002668,0.023687,0.007553,0.050248,0.014136,0.046481,-0.049895,0.005061,0.031973,0.055740,-0.019869,-0.018768,-0.028711,0.036746,-0.059786,-0.019384,-0.032482,-0.062262,0.005905,0.054331,-0.038034,0.033031,0.014124,0.009943,0.043775,0.003015,-0.054560,0.013045,0.015263,-0.005134,-0.019573,-0.047296,-0.023750,-0.055366,-0.052892,0.055201,-0.031462,0.019267,-0.013595,0.021649,0.001449,-0.062113,-0.056799,-0.009639,0.006931,-0.051708,-0.035480,-0.010966,-0.013346,-0.044303,0.050742,-0.050942,0.018943,0.018179,-0.040011,-0.024083,-0.020350,0.015160,-0.025243,0.003211,-0.051582,0.012798,0.051968,0.023973,0.013716,-0.000269,-0.009504,0.033779,0.005313,0.001185,-0.031321,-0.003105,-0.026778,0.027301,-0.017287,0.000197,-0.011672,0.001048,0.005631,0.013152,-0.022551,-0.020662,0.058697,-0.010354,0.015767,-0.026887,-0.026578,-0.001753,-0.029739,0.007114,0.009035,0.011431,0.061409,0.042177,0.000521,0.025992,0.015050,0.009369,-0.027603,-0.045744,0.016567,-0.024084,0.029536,-0.008841,0.021689,-0.036877,0.014907,-0.012502,-0.021628,-0.003834,-0.009155,0.038685,-0.014857,-0.016262,-0.015809,-0.007993,0.058626,-0.013514,0.014385,0.024424,0.057718,-0.051390,0.048668,-0.019833,0.016957,-0.009969,-0.055927,-0.047174,-0.050646,-0.050508,0.041938,0.044621,-0.032146,0.010634,-0.026848,-0.014290,-0.060724,0.033296,0.000445,-0.003731,0.033934,0.037941,-0.055429,0.053027,0.011748,0.047503,0.049854,0.059934,-0.031480,0.020055,0.030394,0.007175,0.023673,0.009664,0.035974,-0.024613};
  parameter real W210[0:249] = {0.043899,-0.055039,-0.009184,-0.052927,-0.033129,0.017756,-0.036697,0.031533,0.009699,-0.043850,-0.054888,-0.058641,0.029141,0.049577,0.016507,-0.030198,-0.054288,0.051919,-0.031127,0.021848,-0.027825,0.038368,0.024402,0.003995,-0.022230,0.020993,-0.037974,0.040113,0.039881,-0.026431,-0.040642,0.004855,-0.058255,0.051001,0.015088,0.013243,-0.012038,-0.006707,0.003500,0.033376,0.048039,-0.013492,-0.006408,-0.017251,-0.025900,-0.018947,-0.046233,-0.017112,0.005690,-0.000179,0.018256,-0.061657,-0.037799,0.048659,0.042764,0.003155,-0.018747,-0.034938,0.001047,-0.028447,0.061685,0.049459,-0.055707,0.027300,-0.034805,-0.036598,0.050757,0.031871,-0.064199,0.058020,0.014600,0.022312,0.008932,-0.018355,-0.017977,0.030134,-0.050120,-0.013898,0.003483,0.021775,0.030446,-0.032244,-0.027469,0.065422,0.026641,0.010006,0.053914,0.005154,0.060706,0.012060,-0.015375,-0.028712,0.030337,-0.029288,0.028627,0.051113,0.019275,0.007714,0.029095,0.018049,0.056517,-0.013563,0.056445,-0.061357,-0.001331,0.048900,0.031657,-0.023371,-0.015531,0.016320,0.015324,0.018115,0.010307,0.052489,-0.036511,0.029536,0.012149,0.024252,-0.013411,0.032389,0.034477,0.012879,0.005926,0.051634,-0.032332,-0.048929,-0.052547,0.035956,-0.015590,0.020311,0.026369,-0.064028,0.006532,0.023069,0.019776,0.059218,-0.048224,0.060307,-0.022785,-0.064723,0.005386,-0.010289,0.027130,0.030894,0.049423,-0.023554,0.037244,0.024316,0.040067,0.014699,0.060580,-0.004270,0.038474,-0.027878,-0.008292,-0.024841,0.029206,-0.008230,0.013096,0.015048,0.024678,-0.008375,0.044300,-0.055049,0.000904,0.009269,-0.058928,-0.053303,0.011853,0.043238,0.058943,-0.055005,0.005140,-0.017223,-0.035480,0.037307,-0.010708,-0.014516,0.050241,0.048679,0.042413,0.005675,0.042159,-0.057041,-0.000205,0.008093,-0.039945,-0.046479,0.005786,0.006698,-0.029415,-0.029435,-0.002781,0.027058,-0.026056,-0.011345,0.059941,-0.052802,0.002054,-0.019667,0.033500,0.033722,-0.014597,0.059851,0.018723,0.014020,0.012542,-0.033532,0.028084,-0.059615,-0.007854,-0.033837,0.002555,-0.040318,0.011599,0.032055,-0.007155,0.045469,0.058217,0.032651,0.050216,0.049112,0.017244,-0.047939,-0.029727,0.025721,-0.015258,0.003665,-0.042258,0.053238,0.024568,-0.062496,0.033245,0.027165,-0.046286,-0.058045,-0.029196,-0.014506,0.056341,0.013839,0.048587,-0.048581,-0.018333,-0.012217,-0.043449,0.008299,-0.003288,0.062789,0.053422,-0.008814};
  parameter real W211[0:249] = {-0.032093,-0.022407,-0.038713,-0.041316,-0.038072,0.055856,0.032315,-0.004896,-0.045796,-0.048081,0.026326,0.003415,-0.042766,0.007107,-0.036603,-0.002667,0.048937,-0.063295,-0.053828,-0.031032,0.048042,0.005650,0.023197,-0.006359,-0.043326,0.016471,-0.052063,-0.059674,0.006244,-0.059103,-0.041175,0.054760,0.041089,0.027122,-0.028836,-0.010378,-0.047309,0.056726,0.025597,-0.000536,0.054039,-0.001288,0.037572,0.050354,-0.057002,0.064389,-0.020388,0.014106,0.015066,-0.066571,-0.001343,0.008169,-0.060549,0.014353,-0.068735,0.018471,-0.052891,0.034229,-0.032890,-0.005940,0.065506,0.023901,0.005567,0.039185,0.005724,0.019304,-0.040037,0.002521,-0.020593,-0.056487,-0.044046,0.011173,0.004450,0.025217,-0.046828,0.025801,-0.036886,0.025026,0.040636,0.011260,-0.034305,0.008848,0.032273,0.045738,-0.037781,0.030090,0.004594,0.065909,-0.035508,-0.013308,0.058542,-0.020441,0.060743,-0.013548,-0.016237,-0.044774,0.001916,-0.008687,-0.039780,-0.061710,-0.045081,-0.020735,0.018324,-0.033025,-0.045166,-0.018334,0.016739,-0.053102,-0.054719,0.057300,0.009150,-0.044537,-0.018193,-0.005225,0.007576,-0.038172,0.057168,-0.058922,0.033453,0.030362,0.035757,-0.045954,0.028342,-0.024472,-0.052937,-0.019323,0.005353,-0.009397,0.034678,-0.007392,0.011043,-0.052133,-0.009357,0.054174,-0.019515,-0.003208,0.019544,-0.046427,0.019800,0.046586,-0.043491,-0.061186,-0.029690,-0.024050,0.032038,0.029012,0.018574,-0.056745,0.039278,0.056528,0.054520,0.004907,0.000377,0.070203,-0.016343,-0.056027,0.013658,0.008074,-0.016091,0.031993,-0.042104,0.037774,-0.035801,-0.038850,-0.050011,-0.024112,-0.049509,-0.028171,0.041105,-0.035093,-0.049853,0.008230,0.045649,0.045986,0.049034,0.067959,-0.051383,0.031125,-0.051010,-0.025226,0.050537,0.000032,0.009082,0.040110,-0.028151,0.013818,0.041769,0.069014,0.049371,-0.017934,-0.042986,0.030439,0.014476,-0.061606,0.042209,-0.012701,-0.056911,0.012895,0.001929,-0.060628,-0.068242,0.015238,0.017720,-0.053622,0.025447,-0.018747,0.027720,-0.029941,0.034030,-0.020354,0.064967,-0.057184,0.034581,-0.037132,0.006361,0.022624,-0.019210,0.004403,-0.017700,-0.054052,0.001224,-0.055258,0.047166,-0.012211,-0.010014,-0.015125,0.041151,-0.041605,-0.055498,-0.003347,0.006028,-0.005022,-0.004035,-0.029051,0.013986,0.015232,0.020550,0.012501,-0.020952,-0.003739,-0.017402,0.059693,-0.046503,0.056152,-0.000158,0.050305,0.029552,-0.007539,-0.043870,-0.022347};
  parameter real W212[0:249] = {-0.062226,-0.032854,-0.006785,-0.001117,-0.018444,0.017632,-0.032909,-0.055870,-0.005279,-0.034912,-0.024235,-0.049707,-0.039342,-0.025779,0.002167,0.019286,0.042168,0.053129,0.000398,-0.048521,0.000240,0.000732,0.060595,-0.036553,-0.045753,-0.060747,-0.012619,0.038702,0.003620,-0.060534,0.051433,-0.021897,0.038797,-0.057911,0.019709,0.040000,-0.009030,0.041858,0.049495,-0.059423,0.053687,0.005227,0.002093,-0.011821,0.015684,-0.024432,-0.020473,-0.004072,0.023200,-0.041837,0.051419,0.033893,0.006085,0.018958,-0.027499,-0.057147,-0.014223,-0.058179,0.015083,0.048770,-0.020389,0.030570,0.035807,-0.051214,0.053628,-0.044185,0.032083,-0.006414,0.033316,-0.007069,-0.053198,0.029987,0.020490,0.053092,0.039863,0.043872,-0.024243,0.014602,0.031157,-0.018477,0.036572,0.062161,0.019252,-0.042751,-0.038878,-0.054488,-0.056486,-0.015191,0.043065,0.000337,0.050249,-0.061589,-0.051639,0.044913,-0.032516,-0.017832,0.036734,-0.040812,-0.028220,-0.021932,-0.032855,0.022311,-0.023289,-0.002456,0.012707,0.060763,-0.000500,-0.040984,0.059772,-0.046733,-0.028777,0.056272,-0.000447,-0.062568,0.016940,0.061999,-0.048950,-0.029986,-0.055726,-0.007035,0.028826,-0.023747,-0.058918,-0.027470,-0.047670,-0.025177,-0.019381,-0.001926,0.025985,0.019724,-0.026158,-0.016111,0.035648,0.027910,0.034789,0.042515,0.006919,0.000328,-0.002560,-0.025442,0.023993,-0.009117,0.021400,0.047816,0.057837,0.010697,0.031270,0.023760,0.018414,0.042776,-0.049559,0.043594,0.023214,0.026126,0.006736,0.025817,0.046856,0.046357,0.034436,0.016842,-0.047963,0.039537,-0.058993,-0.017365,-0.054030,-0.060954,-0.006250,0.022582,-0.027999,0.020558,0.059829,-0.012152,0.016126,0.032314,0.025306,-0.063473,-0.015645,0.053194,-0.026412,0.058606,0.034310,0.037626,0.032653,-0.002994,-0.025577,-0.035419,-0.047646,0.022281,-0.013277,0.038902,-0.029553,-0.049181,-0.033065,-0.044444,-0.066125,-0.055658,-0.024810,0.040590,0.053164,-0.067124,-0.021616,0.061678,0.009143,0.015385,0.014123,-0.037035,0.031513,-0.002374,0.011668,-0.030938,-0.004916,-0.019330,0.006138,0.061330,-0.058822,-0.028468,0.052454,-0.033382,-0.041802,-0.028547,-0.013677,-0.049836,0.057357,0.039323,0.020654,0.004830,0.058038,0.045800,0.006214,-0.041690,0.045105,-0.009032,0.053267,0.045788,0.024163,0.006065,0.002899,-0.017034,0.024211,-0.007975,0.013581,-0.063644,0.018533,0.035066,0.022847,-0.053244,-0.022529,-0.058425,-0.026504,0.051830};
  parameter real W213[0:249] = {-0.033202,-0.053488,0.036266,-0.025742,-0.027891,0.030540,-0.061101,0.003618,-0.062302,0.023872,-0.031539,0.033316,-0.051484,-0.017656,0.050076,0.044802,-0.049827,-0.045486,0.056064,0.016816,-0.004445,-0.051965,-0.000969,-0.031927,0.016967,-0.036213,-0.000667,0.020736,-0.061743,0.045052,0.022106,-0.008192,0.025547,-0.049036,0.044690,-0.060160,-0.026166,-0.030968,-0.025751,0.021201,-0.026473,0.053508,-0.023156,-0.044934,0.023693,-0.042713,-0.029770,-0.026633,0.000493,-0.026977,0.014963,0.025751,0.029381,-0.048336,0.052033,0.005232,-0.002198,-0.006937,-0.018532,-0.006866,-0.019047,-0.059566,-0.014938,-0.046860,-0.000877,0.048030,-0.006443,0.011379,-0.053503,-0.009415,0.014076,0.048621,-0.054368,-0.056985,-0.047049,0.032942,0.023145,-0.045781,-0.044797,0.056762,-0.031183,-0.057316,-0.034437,0.061363,0.001794,-0.014933,0.031672,-0.066763,-0.003293,0.051210,-0.038446,0.038374,-0.000085,-0.011811,-0.059683,0.076932,-0.040856,-0.054009,-0.016228,0.000294,0.023011,-0.009459,-0.057672,-0.036805,0.025111,-0.014294,-0.071616,0.015867,0.052747,0.019472,0.032570,-0.020267,-0.033055,-0.020834,-0.064407,0.032568,-0.074189,0.057988,-0.018848,-0.005520,0.032856,-0.004589,0.063728,-0.039400,0.006575,0.064134,-0.003153,0.025817,0.019826,0.000881,-0.001195,0.052375,0.038993,0.040999,0.030692,0.015854,0.026167,0.024689,0.057651,0.054072,0.022749,-0.001451,-0.027255,-0.025793,-0.015393,-0.011834,0.050946,-0.036929,-0.041273,0.041459,0.057390,0.008484,0.040592,-0.058888,0.054795,-0.025593,-0.062296,0.015154,0.062393,0.033911,0.060473,0.016485,0.034449,-0.002299,-0.017637,-0.018599,-0.036688,0.055301,-0.023689,-0.017258,0.019289,0.032845,0.026524,-0.038538,-0.059145,0.021575,-0.043465,-0.017901,-0.048253,0.044287,-0.021908,-0.054275,-0.003745,-0.044423,0.046909,-0.005450,0.031773,-0.023965,0.050512,0.053719,0.048130,0.009444,-0.037385,0.047230,0.023190,-0.026721,0.036296,0.003997,-0.002529,-0.018963,0.018695,-0.010772,0.014964,0.051091,-0.030271,-0.046730,-0.021103,0.006570,0.051860,0.004167,-0.059595,-0.018358,0.027122,0.038320,0.053120,0.058069,0.051500,0.043911,-0.000379,-0.013812,-0.015042,-0.055277,0.023314,0.011504,-0.040250,-0.035106,0.046824,-0.043117,0.024421,-0.015369,0.066341,-0.017673,-0.036348,-0.009973,0.011003,-0.034738,0.010458,0.010722,0.034328,-0.010297,-0.020888,0.005011,0.024847,0.051097,0.058044,-0.014885,0.008898,0.039599,-0.057891,-0.030538};
  parameter real W214[0:249] = {0.035616,0.059598,0.002010,-0.045360,-0.017256,-0.005883,-0.057891,0.042345,0.051944,-0.020252,-0.021530,-0.008574,-0.021644,-0.001868,-0.000695,-0.010775,-0.038098,0.024972,-0.054232,-0.031455,0.036646,-0.015930,0.046869,-0.002520,0.027571,-0.060113,-0.049495,-0.023437,-0.027701,0.042706,-0.046629,0.021806,0.047108,0.029877,0.016407,-0.005635,-0.005482,-0.000473,-0.031015,0.033414,0.001933,-0.062233,0.058852,-0.006283,-0.047902,0.058767,-0.026796,-0.058690,0.038648,0.054133,0.036016,-0.022171,-0.029202,0.013181,0.003103,0.046576,-0.037461,0.006849,-0.039324,-0.032224,-0.036627,0.016730,-0.027542,0.050363,0.036914,0.036980,-0.028765,-0.017013,-0.059147,0.007759,0.006674,-0.044280,0.058179,-0.001901,0.001997,-0.025449,-0.022499,-0.052237,-0.041183,0.003741,-0.035388,0.037768,-0.052304,0.027118,-0.059404,-0.018839,0.006115,0.007200,0.015245,0.001644,-0.047418,-0.028954,0.022723,0.032566,0.045070,-0.003487,0.041881,-0.035761,-0.037595,0.008666,-0.022519,-0.064527,0.033491,0.016277,0.004999,0.052786,0.055525,0.048226,0.008711,0.037657,0.038284,-0.030106,0.001547,-0.009785,-0.006290,0.042826,-0.046269,-0.039086,-0.039971,-0.037120,-0.031314,0.020148,0.044360,0.024457,0.022080,0.007313,0.045851,0.019697,0.016697,-0.049577,0.057863,-0.014472,0.024050,0.008463,-0.023268,-0.014617,0.055394,0.042715,0.000916,0.053948,-0.041156,-0.042609,0.057220,0.061034,0.047206,0.011490,0.012117,0.008571,-0.011163,-0.024853,0.001779,0.034205,0.008462,0.040142,0.011100,0.045828,0.016097,-0.031082,-0.033745,-0.017541,0.018554,0.019630,0.039958,-0.023565,0.047794,-0.011491,-0.037867,0.039985,-0.013394,0.036667,-0.020281,0.033389,0.000652,0.051109,-0.008411,0.007850,-0.031380,0.011582,0.047087,-0.009502,0.037725,-0.041000,-0.049847,-0.025114,0.004257,0.007881,0.003428,-0.057935,-0.061620,0.033337,0.053604,0.039220,-0.022952,0.041445,-0.004876,-0.059031,-0.059161,0.020621,0.023761,-0.059986,0.006234,0.058584,0.043154,-0.032340,0.023394,0.003944,0.047838,0.014699,0.009151,-0.020150,0.064270,0.043900,0.024907,0.065848,0.003581,0.015089,0.059369,0.015527,-0.061059,0.007193,-0.045719,-0.023079,-0.049350,0.053827,0.007382,-0.059204,-0.041365,-0.022267,-0.040407,0.059954,0.026618,0.023890,0.063644,0.019321,-0.045158,-0.032928,-0.049225,0.030999,-0.015205,0.059717,-0.026141,-0.005204,-0.028634,-0.018786,-0.059995,0.030179,-0.012638,0.053119,-0.041961,0.031662};
  parameter real W215[0:249] = {0.005749,0.002371,-0.050208,0.041198,-0.043422,-0.030959,-0.046073,0.011340,-0.049776,-0.051785,0.034719,-0.035177,0.040349,-0.058987,0.002081,0.036816,0.018011,0.059008,0.038994,0.035278,-0.042985,0.012709,-0.000654,0.041273,0.011004,-0.044189,-0.021986,0.010184,0.033447,0.052624,0.032248,-0.017827,0.064031,-0.043762,0.007228,-0.042574,-0.051897,0.041147,0.039187,-0.022391,-0.064256,-0.056368,0.061666,-0.063231,0.028550,0.062050,0.045820,-0.034831,0.058940,0.069021,-0.045105,0.008322,-0.007650,0.048391,0.013776,0.056070,0.061461,0.013267,-0.031691,0.039377,-0.033532,-0.066004,-0.047283,-0.025195,-0.055163,0.053324,0.025391,0.000888,0.003057,0.008508,-0.021670,-0.030504,-0.050871,-0.022416,-0.072168,0.062008,-0.048183,0.028582,-0.018600,0.011899,0.041731,0.053681,0.047264,0.051672,-0.000150,-0.028231,-0.024965,-0.025075,-0.054103,0.071625,0.001803,0.041398,-0.009868,-0.004379,-0.023373,0.046784,0.038953,0.052850,0.035875,0.004395,0.000959,-0.026150,-0.004438,-0.038844,-0.051421,-0.024568,-0.008801,-0.064086,-0.030203,0.048043,-0.061119,-0.026422,0.059940,-0.040265,-0.057002,0.024583,-0.071776,-0.015080,-0.025326,-0.054228,0.096145,0.018749,0.018753,-0.021815,0.012924,0.068956,-0.054103,0.030911,0.037736,0.033337,0.020671,-0.004880,0.015538,0.067456,0.047270,-0.061773,-0.038844,0.009777,0.036573,0.027219,0.033633,-0.026991,0.009885,0.051637,0.041544,0.000788,-0.040428,0.028544,-0.001486,-0.062297,-0.014253,-0.073428,0.060556,-0.076327,-0.057013,-0.000012,-0.001719,0.045788,-0.029861,-0.052398,0.029304,-0.000623,0.006186,-0.036929,-0.048252,-0.062575,-0.047901,-0.040333,0.034878,0.032569,0.053012,-0.002853,-0.032499,-0.070282,0.041831,0.031361,0.030282,-0.049150,-0.011698,-0.022615,-0.028360,-0.048950,0.054320,0.021308,0.058896,-0.060363,0.051970,-0.049671,-0.008297,0.009030,-0.051137,-0.035121,0.021654,0.001312,0.099510,0.004007,0.001799,-0.004854,-0.053136,-0.009780,-0.009265,0.000679,-0.054017,0.018360,0.042679,0.062282,-0.009308,0.042659,0.048767,-0.031859,-0.062690,-0.010646,0.062621,0.002993,-0.034765,0.017180,0.048794,-0.041306,0.071990,0.023953,0.001834,-0.036729,-0.039794,-0.037261,0.025875,0.061678,0.050281,-0.004941,0.057155,-0.050959,0.031379,-0.023243,-0.008800,-0.008394,-0.053570,-0.045872,0.058660,0.010963,-0.007445,0.044178,-0.020046,-0.064506,0.024444,0.034250,-0.040998,-0.023526,0.064783,0.014550,-0.022097,-0.018341};
  parameter real W216[0:249] = {0.005180,0.045239,-0.015106,-0.054405,0.043880,0.063744,-0.062828,-0.046783,0.039168,0.013786,-0.004492,-0.058576,0.018537,-0.041517,-0.038317,0.013129,0.028477,0.043600,-0.054391,0.003688,-0.013452,-0.035164,0.014306,0.019676,0.015883,-0.008198,0.044887,-0.039039,-0.041588,-0.033417,0.020798,0.043578,0.004502,-0.042023,-0.053550,0.061669,0.031921,-0.022395,-0.051102,-0.013313,-0.056751,0.006454,-0.017610,-0.037613,-0.026934,-0.001970,0.055336,-0.003834,-0.021846,-0.054656,0.038799,0.003885,-0.028305,0.038252,-0.016522,0.044677,-0.061827,0.000929,0.018910,-0.018232,0.048736,-0.059495,-0.045598,0.017613,-0.013541,-0.020462,-0.004099,-0.056735,-0.017515,-0.036061,-0.013490,-0.058172,0.016932,-0.025422,0.040567,-0.028616,0.054034,0.013281,-0.001536,-0.043310,0.026396,-0.040977,0.035711,-0.035280,0.057431,0.011367,0.028855,0.030037,0.010910,0.033617,-0.039891,0.026922,0.059882,-0.050067,-0.061772,0.060979,0.003838,0.055020,0.005383,-0.058864,-0.013270,-0.052686,-0.011598,0.025179,-0.041817,-0.033698,-0.033404,-0.041160,0.025616,0.056108,0.055348,0.040346,0.043123,-0.015505,-0.030705,-0.053110,-0.008204,0.041562,-0.031987,0.050748,-0.035243,-0.027487,-0.032155,0.045606,-0.015732,0.025237,0.046411,0.012415,0.022206,0.007387,-0.031593,-0.058832,-0.009798,0.017560,0.024230,-0.004185,0.040158,0.064429,0.005228,-0.023953,0.057536,-0.046335,-0.012555,-0.035564,-0.037942,-0.032475,0.033861,-0.022452,0.008322,0.029358,0.028550,0.044819,0.015652,0.030989,0.064175,0.017130,0.044065,-0.036091,0.049422,-0.045656,0.021977,0.020939,-0.044637,-0.038242,-0.044084,-0.044389,0.015743,0.037716,-0.053028,-0.011682,0.018859,-0.012047,-0.011758,0.016699,-0.007107,-0.018512,0.000217,0.015274,0.043386,0.042570,-0.047642,0.007787,-0.042763,0.029946,0.004403,0.032231,0.013860,-0.057169,-0.057821,0.042515,0.015330,-0.036551,0.018239,-0.037296,0.043860,-0.016211,-0.042678,-0.052538,0.054658,-0.044059,0.057792,0.016091,0.027283,-0.006732,-0.046846,-0.002370,-0.055547,-0.023509,-0.030633,-0.050397,-0.018629,-0.042965,0.034742,-0.052425,0.037879,-0.028990,0.043317,-0.064534,-0.061872,0.023223,-0.017238,0.034871,-0.011906,-0.043243,-0.043221,0.062496,-0.059104,-0.019755,-0.059612,0.044728,0.048599,0.024715,-0.049432,0.033182,0.001796,0.002704,-0.039934,-0.008277,-0.012645,-0.024585,-0.001141,-0.060627,-0.056423,-0.038308,0.055552,0.009053,0.036002,0.043326,-0.047517,0.002325};
  parameter real W217[0:249] = {0.016169,-0.004150,0.001427,0.003810,0.041498,0.046503,0.012412,0.003126,0.025754,0.005549,-0.029712,-0.012702,0.040924,0.008348,-0.015984,0.033585,0.026271,0.047202,-0.062498,0.064014,0.043788,-0.051056,-0.040209,-0.024933,-0.055143,-0.028939,-0.027482,0.006813,-0.025807,-0.041611,0.055606,0.022820,0.013728,0.038435,0.027758,0.001279,0.042980,0.051100,-0.006982,-0.010020,0.021562,-0.011585,-0.057435,0.009700,0.000654,0.023960,-0.061730,0.020614,0.021758,-0.004429,-0.046292,-0.013033,-0.020246,-0.031255,-0.013916,-0.059778,-0.044820,-0.012825,-0.018987,-0.034152,-0.057066,0.049994,0.008426,-0.005973,0.025706,0.025040,-0.010784,-0.052466,-0.018724,0.024434,0.044869,-0.019371,0.053834,0.011985,-0.023562,-0.021470,-0.044201,-0.049888,0.038967,0.010116,0.020909,-0.014028,0.052147,0.000724,-0.051578,0.004373,0.044619,0.061497,-0.013216,0.028616,-0.024184,0.004141,0.057216,0.018374,-0.038099,0.053008,0.054626,-0.062101,-0.039869,-0.000310,0.023185,0.030559,0.049369,0.058131,-0.052244,-0.026900,0.028897,-0.021350,0.025478,-0.063832,0.055009,0.044658,-0.055123,0.059809,-0.024171,-0.032111,0.051923,-0.055800,0.053082,-0.004230,0.054317,-0.004018,-0.055377,0.034163,0.056829,-0.057241,-0.039211,-0.012662,-0.022461,-0.040097,0.037906,-0.014754,-0.027513,-0.010398,0.012806,-0.022793,-0.057498,-0.034135,-0.029445,0.001108,-0.042877,0.025427,-0.037783,-0.042310,0.025063,-0.009313,-0.038824,-0.034009,0.042861,0.016918,-0.042173,-0.037043,-0.015248,-0.028046,-0.020150,-0.040652,-0.006908,-0.025238,-0.056682,0.050536,-0.013442,-0.040104,-0.021241,0.062066,0.008544,0.061707,0.006709,-0.049202,0.042908,-0.023608,0.029230,-0.029148,-0.058000,-0.010507,-0.029379,-0.036695,0.004002,-0.000147,0.029679,-0.021746,0.031002,-0.042283,0.002285,-0.038181,0.037480,0.054659,-0.056142,0.030500,-0.024521,-0.021169,-0.000089,0.045095,0.033268,-0.026460,-0.060309,0.035906,0.046253,0.043332,-0.047079,-0.041032,-0.052174,0.019382,-0.051498,-0.055012,0.060318,0.023865,0.069667,-0.051874,-0.033270,0.013348,-0.002375,-0.040782,0.019616,-0.024064,0.049917,-0.037453,0.032549,-0.059710,0.008740,0.047189,0.041264,-0.057229,0.034618,0.056438,0.050145,-0.007021,-0.031105,-0.002344,-0.047489,0.050361,0.059245,-0.015878,0.000827,0.020251,0.015779,-0.035430,0.004481,-0.055551,-0.025815,-0.025164,-0.037319,0.023446,-0.045671,0.014533,-0.028510,-0.017724,-0.013841,0.042183,0.023770,-0.051439};
  parameter real W218[0:249] = {0.035819,0.008131,0.036237,0.044643,-0.024541,0.025762,-0.025147,0.005334,0.001192,-0.053013,-0.059816,0.014104,-0.051525,-0.008674,-0.019743,0.049620,-0.005719,-0.051201,0.040979,-0.007532,-0.052180,-0.015652,0.019575,-0.058065,-0.017926,-0.047776,0.030837,0.032776,0.014056,-0.063757,-0.026976,-0.061220,0.054210,-0.062057,-0.024903,-0.055038,-0.034763,0.036049,-0.032148,-0.055410,-0.060820,0.038634,-0.003988,-0.032075,0.002542,0.028416,0.055231,0.016512,-0.002050,-0.051740,-0.032044,0.002573,0.030102,-0.033099,0.019112,-0.051211,-0.041548,-0.062619,0.017108,-0.016292,0.057076,-0.061008,0.058686,0.026598,-0.059245,0.013725,0.041304,-0.034291,0.001327,-0.020125,0.023325,0.052188,0.042913,0.054793,-0.024902,-0.058144,0.017968,-0.001096,0.054451,-0.058710,-0.033377,-0.058760,-0.008526,0.062691,-0.060772,-0.034881,-0.043858,-0.003389,-0.015948,0.028916,-0.032519,-0.031080,-0.052026,-0.032554,0.006678,-0.022501,0.053400,-0.049485,0.034383,-0.033694,0.049137,0.043725,-0.039313,0.008776,0.047492,-0.052407,0.015893,-0.041524,-0.006677,0.019189,0.001207,-0.048325,-0.053555,-0.000605,-0.040593,0.001666,0.003939,-0.019536,0.021644,-0.015324,0.055661,0.016088,-0.024060,-0.004730,-0.004517,-0.049406,-0.019788,-0.009563,-0.025366,-0.048587,-0.060008,0.050461,0.047499,0.012534,0.039494,0.010950,-0.002456,-0.007370,-0.035457,-0.035361,0.003121,0.015076,0.007444,0.054692,-0.051567,-0.014559,-0.039982,0.039793,-0.048655,-0.030268,0.062710,0.049523,-0.051730,0.019181,-0.007511,0.049767,0.039661,0.033894,0.060961,-0.060431,0.007210,0.035637,0.051848,0.001123,-0.050653,-0.002441,0.000313,-0.012944,0.004086,0.038403,0.007813,0.045106,0.042218,0.022589,-0.009678,-0.029580,-0.065214,0.045496,0.021353,0.000625,0.012747,0.053034,-0.058933,-0.024767,0.020352,0.027694,-0.022517,0.014214,-0.056228,0.020843,-0.000059,0.011045,0.031242,0.059994,0.004706,-0.017054,-0.052384,-0.016192,0.053276,0.011376,0.049970,-0.037723,-0.044493,-0.018923,-0.063717,0.033689,0.040095,0.027071,0.053455,0.026078,-0.028627,0.034751,0.031500,-0.039508,0.003747,0.020638,0.031735,-0.056138,0.008230,-0.058146,-0.032991,-0.057990,-0.059342,0.050792,-0.006701,0.064370,0.000645,0.033486,-0.021649,-0.055632,-0.006647,-0.029312,-0.061834,0.040431,-0.060930,0.006487,0.013067,0.020782,0.000106,0.000852,-0.009500,-0.012715,-0.065175,-0.049275,-0.010067,-0.002510,0.025007,-0.005642,0.057678,-0.038364};
  parameter real W219[0:249] = {0.042325,-0.022340,0.006898,-0.051421,-0.053452,-0.045025,0.006562,-0.044456,-0.018780,-0.026651,-0.048355,-0.014918,-0.013226,-0.025278,0.019018,0.019308,0.003906,0.028314,-0.056294,0.052489,0.032061,0.010891,-0.060765,-0.010999,0.011074,-0.051309,0.029501,-0.035051,-0.001591,0.015570,-0.013079,-0.029198,0.020615,-0.057902,0.017926,-0.009046,-0.019219,-0.000614,0.000035,0.019830,-0.029673,0.047810,0.018275,0.051432,-0.034425,-0.046585,0.040350,-0.034570,0.034615,-0.030866,0.018240,-0.041622,-0.045811,0.038198,0.053381,-0.011227,-0.034304,-0.040497,0.011997,0.026850,0.049166,0.049379,-0.011032,0.056293,0.004703,0.004904,0.024667,-0.014363,-0.045447,0.063250,-0.027860,-0.060952,-0.050385,0.061611,0.060480,-0.048426,0.000630,-0.002883,-0.050295,-0.020804,-0.038869,-0.063035,-0.057469,-0.027623,0.060983,-0.046466,-0.039729,-0.052435,0.057289,0.030989,-0.060916,0.048674,-0.018417,-0.065802,0.047474,-0.008460,0.027862,-0.042922,-0.032217,-0.020320,-0.042577,0.060214,-0.048650,-0.007137,0.020494,0.040201,-0.006140,-0.002525,-0.050258,-0.023422,-0.002156,-0.011730,-0.063069,0.055504,-0.030427,-0.035015,0.056784,-0.015430,-0.052566,0.051858,0.015074,0.054373,-0.007513,0.045312,0.044990,-0.022425,-0.030881,-0.045630,-0.007682,0.014191,-0.043775,0.028629,0.017155,0.042944,0.027064,-0.017100,-0.021533,-0.009596,-0.000055,0.062713,-0.035643,-0.020069,0.064358,0.023235,0.058178,-0.047153,0.026304,0.052451,-0.056575,0.002001,0.040587,0.058263,-0.066418,0.025078,0.038985,0.029978,0.012108,0.036305,0.007831,-0.011238,0.027419,-0.060748,-0.010666,-0.006322,-0.031212,0.037765,0.050482,0.012432,-0.007597,0.024501,-0.046784,-0.023530,0.006741,0.062655,0.017746,-0.042804,0.025457,0.058196,0.058033,-0.019405,0.000042,0.052424,-0.041324,0.049889,0.013662,-0.036389,0.011543,-0.031035,-0.031383,0.001454,-0.002759,0.033956,0.060025,0.043219,-0.006840,0.046381,0.051493,-0.035897,-0.002981,0.006798,-0.043540,0.019073,0.001818,0.003795,-0.000162,-0.058820,-0.010136,-0.012991,0.054051,0.018124,0.006886,0.019413,0.055242,-0.004519,-0.035679,0.014989,0.023582,-0.006899,0.029180,-0.058404,0.020129,-0.020286,0.027124,0.021819,-0.033410,-0.037645,0.008875,0.016611,0.052569,-0.006718,-0.028487,-0.005313,-0.028486,-0.059538,-0.046485,-0.030009,0.019091,0.033779,0.043480,-0.036105,0.056866,0.010679,0.049969,-0.059098,0.014230,-0.050826,0.057269,-0.059694,0.025928,-0.016081};
  parameter real W220[0:249] = {0.008843,0.044475,0.057262,0.059287,-0.007977,-0.042778,-0.021860,0.001899,0.009184,-0.016364,0.043610,0.027857,-0.028675,0.067547,0.005401,-0.060115,0.048487,-0.033655,0.016360,0.037109,0.054001,-0.050418,-0.005995,-0.017868,-0.055650,-0.020354,0.015430,0.031480,0.008502,-0.012741,-0.041868,0.023918,0.022333,-0.035611,-0.066034,0.038819,-0.010051,-0.010497,-0.049479,-0.005600,0.000286,-0.052436,0.016823,0.006681,0.030076,-0.041488,0.050575,-0.031423,-0.026308,-0.002180,0.067029,0.000269,-0.070583,0.001538,0.027566,0.030621,0.015787,-0.066488,-0.064612,-0.059493,-0.053307,0.051996,-0.011982,0.006136,-0.049141,0.064850,-0.016137,0.053151,-0.004484,-0.008083,0.004858,-0.010910,0.055033,0.001384,0.045506,-0.066687,0.012613,0.025800,-0.037247,0.012575,-0.015963,-0.006189,-0.049954,-0.015809,-0.056195,0.016040,0.066753,-0.049446,-0.047522,0.044714,-0.020334,0.038001,0.059674,-0.000283,-0.057912,-0.065489,-0.015152,-0.028065,0.011787,-0.001749,-0.042458,0.010116,0.017948,0.061224,-0.031129,-0.051801,0.047991,0.046694,0.062674,-0.000168,0.039343,-0.017633,0.035702,0.050436,0.011021,-0.024379,0.061958,0.031597,0.063780,-0.043065,0.009952,0.017812,-0.052987,0.054556,-0.018470,0.020505,-0.057579,0.006035,0.022234,0.042165,-0.037452,-0.007284,-0.047277,-0.007898,0.018837,0.012796,-0.049303,-0.055432,-0.021415,0.042485,-0.014840,0.009383,-0.059333,0.031054,0.020800,0.024817,0.054635,-0.054501,-0.028505,-0.017580,0.015818,0.053927,-0.010449,-0.028633,0.044268,0.004092,0.003042,-0.034574,0.023974,-0.017945,-0.029964,0.038102,0.008814,-0.028902,0.005043,0.002329,-0.024076,0.021233,0.060698,-0.008394,0.039556,0.062515,-0.037949,-0.028624,-0.038602,-0.040304,-0.001248,0.020126,-0.057492,-0.016407,-0.015117,-0.035238,0.012393,0.056052,0.028277,0.045455,-0.008470,0.034872,-0.013804,0.023775,-0.049192,0.073948,0.042282,0.008385,0.034725,0.053027,0.055533,-0.041709,-0.038859,-0.032320,0.030544,-0.017858,0.024549,0.000701,0.029350,0.033404,0.060148,0.053455,0.042247,-0.015180,0.019743,0.025922,0.018252,0.019506,0.018443,-0.012591,0.037511,0.042100,-0.003102,-0.041049,0.023654,0.049200,0.034471,-0.033193,0.019347,-0.056775,0.048162,-0.013501,-0.013478,-0.034786,-0.050367,-0.017485,0.024481,-0.001397,-0.042926,-0.011488,0.019408,-0.004494,0.016220,-0.014178,0.004130,0.010569,0.010183,-0.048485,-0.027637,0.006635,-0.064569,-0.068565,0.023780,-0.024743};
  parameter real W221[0:249] = {-0.011965,0.059592,0.017129,-0.066360,0.052168,0.032042,-0.008039,0.049503,0.061747,-0.014016,-0.065676,0.000832,0.058975,0.031500,-0.045438,0.019960,-0.008233,0.006247,0.015560,-0.000569,0.037918,-0.026282,0.021899,0.022742,0.019751,-0.001651,-0.009961,-0.039758,-0.058523,0.048348,-0.000459,-0.052707,-0.047743,0.059528,-0.000155,-0.044742,0.049250,-0.002358,0.033577,0.068196,0.021141,-0.044831,-0.054745,0.013241,-0.044179,0.051590,-0.012154,0.037048,-0.027775,-0.056644,0.009688,-0.051932,-0.063209,0.001694,-0.009509,-0.011730,0.043158,-0.037680,0.038845,0.059144,0.000422,-0.003306,0.011355,-0.043448,-0.009744,-0.043422,0.007528,-0.036606,-0.043829,0.013549,-0.023289,0.023137,-0.032843,-0.042710,-0.067001,-0.014821,0.034255,-0.034706,-0.022745,0.019386,0.060512,-0.028758,0.057464,-0.001289,-0.025432,-0.000285,-0.053539,0.005939,-0.040057,0.023146,0.016942,0.010968,0.028260,-0.060996,-0.016417,0.046855,0.015124,-0.004841,-0.004160,0.029001,0.005809,-0.018427,0.038743,-0.025404,-0.048769,-0.055271,-0.001275,0.027392,-0.021419,-0.030364,0.024487,-0.056084,-0.039228,-0.039901,0.018974,-0.049674,0.041238,-0.055612,-0.042009,-0.014972,-0.046203,0.039208,0.043934,0.053946,0.034125,-0.030838,0.033074,-0.030634,-0.025209,0.043816,-0.008722,-0.053812,0.045030,-0.058416,0.037488,-0.041413,0.030767,-0.000947,-0.022218,0.024340,0.054654,0.009291,-0.011941,-0.039107,0.050201,-0.033729,0.011994,0.003284,-0.045153,0.015308,0.002340,-0.046929,0.062552,-0.008492,-0.021902,0.029199,0.024098,-0.037021,0.019435,-0.053471,0.064006,-0.025830,-0.005645,-0.023616,0.013994,0.004094,-0.031051,0.034892,-0.059633,-0.059133,0.025706,-0.048531,-0.049627,0.046008,-0.026057,0.049745,-0.025056,0.048479,0.018291,0.061227,-0.043503,0.054954,-0.039157,0.024508,0.055259,0.048487,0.017168,0.036830,0.003103,-0.057980,-0.037424,0.025017,-0.024231,-0.039684,-0.010967,-0.053715,-0.046487,0.047625,0.049737,0.008534,0.049515,-0.028800,0.005225,-0.044269,-0.019255,0.056191,-0.026739,-0.029448,0.035040,-0.026182,-0.068694,-0.023329,-0.045529,-0.038409,0.021746,0.056791,0.047211,-0.001481,-0.018776,-0.002531,-0.042195,0.053886,-0.036235,0.003131,-0.014158,0.008643,-0.021441,0.035256,-0.001342,-0.049912,0.040428,0.061642,0.009585,0.029490,-0.042563,0.064477,0.016601,-0.038726,-0.064904,-0.002671,0.040574,0.059298,0.040229,-0.006402,0.010091,-0.046489,0.059513,-0.054244,0.011589,-0.027908};
  parameter real W222[0:249] = {-0.001576,0.052591,-0.033317,0.074758,0.025091,-0.027734,0.060910,0.019483,0.032503,-0.068787,0.034996,-0.055699,0.032130,0.024269,0.065675,0.043715,0.003793,0.061071,0.023051,0.057489,0.024572,-0.020178,-0.009446,-0.012951,0.006820,-0.030253,0.032645,-0.011802,-0.057855,0.009631,0.027605,-0.056946,0.023192,0.031103,0.059729,0.014893,-0.012007,0.037497,0.073468,0.019168,0.052996,-0.028543,0.053172,-0.004664,0.034173,-0.003491,0.033872,-0.026808,-0.007195,-0.033093,0.046410,0.019415,0.018327,-0.041147,-0.071710,-0.067194,0.037372,-0.019313,-0.017164,0.032372,0.049674,-0.010937,-0.004304,-0.016049,0.032622,-0.028314,0.040875,0.026265,0.041759,-0.004859,-0.026264,-0.000532,0.047172,0.027706,-0.028870,0.004739,0.041528,0.016129,0.001322,-0.007640,-0.064250,0.037317,-0.068925,0.083860,-0.033971,0.034607,-0.027828,-0.051431,0.049918,0.063413,0.048061,0.021022,-0.030644,0.067112,-0.009955,0.009626,-0.049236,-0.050220,-0.044027,-0.042562,0.014918,-0.064852,-0.037539,0.044163,0.002569,-0.043569,-0.021934,0.002838,0.009035,0.063683,-0.042647,0.006650,0.023467,-0.038054,-0.039707,0.021409,-0.057917,0.045966,0.010002,0.042987,0.031332,0.003078,-0.022657,-0.008715,0.039925,0.009154,-0.040596,0.017533,0.040100,0.006087,0.012615,-0.045494,0.011917,0.046411,-0.023227,-0.030297,-0.009613,-0.015649,0.029719,0.042561,-0.019327,0.043330,-0.054381,0.059578,-0.028841,0.007685,-0.059929,-0.036935,-0.029453,-0.029310,0.007375,-0.036052,0.026257,0.008429,-0.003437,0.005615,-0.032424,-0.046262,-0.041573,0.046263,-0.023392,0.022225,0.035883,0.020124,0.024271,-0.008986,0.016219,-0.013272,0.044544,-0.011097,0.032601,0.030478,0.007288,-0.049717,-0.013445,0.065290,-0.017160,-0.032532,-0.027656,-0.043071,-0.036007,0.053310,-0.062405,0.040372,0.040701,-0.018688,-0.036657,0.038549,0.027293,0.050729,-0.064483,-0.027573,0.018032,0.013273,-0.011181,0.024916,0.053690,-0.029289,0.009220,0.043197,-0.069013,-0.056504,0.034740,0.023484,-0.024754,-0.039109,0.076777,0.045360,-0.046237,0.010970,0.009794,-0.046926,0.054834,0.002117,-0.051766,-0.028928,-0.026008,0.055083,0.038518,-0.034398,0.035375,-0.065529,0.068220,-0.019350,0.018691,-0.012911,-0.040254,-0.021785,-0.054117,-0.021966,0.053334,-0.031162,0.058940,-0.034578,0.007606,0.025262,0.061138,0.067132,0.028156,-0.030294,-0.003857,0.043910,0.047097,0.007048,0.050658,-0.009081,0.050850,0.023356,-0.052861,0.043587};
  parameter real W223[0:249] = {0.007664,-0.016320,-0.036680,0.055809,0.025327,0.024747,0.067856,0.008041,0.058876,0.049257,-0.061631,-0.057293,0.007855,-0.032328,-0.032133,0.012702,-0.004386,0.016515,-0.012671,0.029845,-0.005722,0.066614,-0.041458,-0.065217,-0.060770,-0.046374,0.024963,-0.008994,0.003353,0.039063,0.013394,0.043533,0.030943,0.034824,0.041945,0.055350,0.030598,-0.046407,-0.009557,-0.008637,-0.048082,-0.032811,0.030393,0.043514,0.030294,-0.044988,0.037616,0.050699,-0.054150,0.015496,-0.013724,0.054402,-0.002878,0.020704,0.064698,-0.041618,-0.055384,-0.006509,0.067001,-0.063566,0.005751,0.029194,-0.025428,-0.019319,-0.010687,0.009137,-0.023628,0.049598,-0.026339,-0.048879,0.056205,0.032277,-0.055384,-0.012692,0.035334,0.047695,-0.025044,-0.020888,-0.001992,-0.050889,0.016408,-0.000100,0.047914,0.051381,0.009316,-0.043631,-0.038079,-0.054528,0.028204,0.037918,0.002413,0.022991,0.007696,-0.054032,-0.030121,-0.056040,-0.024641,-0.013768,0.030141,-0.000614,-0.022126,0.000571,-0.043072,0.030771,0.036256,-0.056263,-0.062631,0.008030,-0.052194,-0.048977,0.020797,-0.055582,0.008334,0.009849,-0.023735,0.038534,0.067775,-0.057623,0.001546,-0.061619,-0.008726,-0.034759,-0.042128,0.028004,0.018747,-0.045920,0.023032,-0.020595,-0.061747,-0.003384,0.055948,-0.013905,0.019804,0.041957,0.010213,-0.034217,0.005305,-0.055836,0.022461,-0.041429,0.003849,-0.036497,-0.049813,0.055474,-0.054338,0.056200,0.023464,0.045988,-0.025336,0.042696,-0.000356,0.001108,0.002296,-0.026965,-0.000168,0.039277,-0.063089,-0.014882,-0.011693,0.061013,-0.048324,-0.050061,0.039086,0.044880,0.036218,0.068206,0.042745,0.039819,-0.062481,-0.040400,0.039710,0.057627,0.031008,0.061405,0.057282,-0.003190,0.044189,0.001032,0.033695,0.009254,0.039935,0.034651,-0.057111,0.015937,0.018384,0.034755,0.051379,-0.036104,-0.032404,-0.029303,-0.044191,0.058474,-0.050112,-0.062662,0.019012,0.022795,-0.036852,0.052671,0.060524,-0.039928,-0.056211,-0.013709,-0.009653,-0.027685,-0.004859,0.046211,0.027210,0.039080,-0.059910,-0.017255,0.003717,-0.020541,0.023489,-0.023404,-0.013806,-0.034916,0.001056,0.005537,0.023415,-0.032191,-0.035745,-0.019147,-0.033974,0.034778,-0.035834,0.048702,-0.045955,0.064080,0.051244,0.037792,0.033063,0.054055,0.000658,0.048333,0.049895,0.023547,-0.043472,-0.023343,0.044609,-0.029616,-0.030405,0.050219,0.032414,-0.013374,0.046223,0.040601,0.054347,-0.008891,0.038033,0.041218};
  parameter real W224[0:249] = {0.037214,0.003638,0.035812,-0.049775,-0.062439,0.058897,-0.018172,-0.032124,-0.043339,0.005085,-0.036593,0.021255,-0.052102,0.033206,0.023587,0.038941,0.027271,-0.055668,0.016441,-0.044230,-0.033306,-0.060030,-0.038012,0.031146,-0.006310,0.051862,-0.059239,-0.005632,0.019633,0.019529,-0.002066,0.047917,0.044101,0.015007,0.055553,0.026577,0.042281,0.017033,-0.056568,-0.051252,0.052828,0.005645,0.014004,0.055114,0.021487,-0.052425,-0.026532,0.003885,0.059834,-0.040486,0.046090,0.046796,0.050321,0.035087,0.055480,0.037773,-0.015300,0.049989,0.030027,0.028577,-0.019986,-0.046844,-0.032404,-0.008130,-0.026004,0.055832,-0.023004,0.034718,0.007484,-0.020484,0.001961,0.006683,-0.041968,-0.051096,-0.021151,-0.060748,-0.004267,-0.063677,-0.006882,-0.053035,0.019503,-0.010674,-0.034738,0.050492,-0.052688,-0.060994,0.005411,-0.022274,-0.015438,-0.011684,-0.032531,-0.037945,0.063123,-0.063896,-0.000214,-0.033733,-0.048425,0.061737,0.055543,0.039184,0.027625,0.020134,-0.032322,0.017500,-0.036827,-0.059832,0.038689,0.010707,-0.054932,0.034978,-0.023469,-0.053250,-0.062644,0.030824,0.059868,-0.008349,0.004903,-0.013225,-0.038463,-0.011048,0.025697,0.058744,0.057637,-0.047512,-0.018135,0.013958,0.050227,-0.061815,-0.001608,-0.045769,0.051252,-0.062163,-0.035558,0.044729,-0.051638,0.018067,-0.022914,-0.010036,-0.022827,-0.027032,0.004365,0.001405,-0.010781,0.055418,0.014750,0.000726,0.044039,-0.035152,0.054123,0.046747,-0.057952,0.047509,0.038116,0.011847,-0.027412,0.000914,0.026528,0.058288,-0.017726,0.032304,0.012952,-0.052409,0.046297,0.035808,-0.018471,-0.000368,0.006395,-0.030100,0.006443,0.028952,0.043458,-0.038285,0.000705,-0.001544,-0.055719,0.051871,-0.010221,-0.034865,0.005676,0.037791,-0.038012,-0.055339,-0.014302,0.023787,0.008047,-0.028181,-0.059403,-0.017606,0.011360,0.034963,0.046295,-0.032353,-0.030569,-0.015127,0.023170,-0.033815,0.020260,0.004326,-0.043462,-0.046324,0.031795,-0.048017,0.027979,-0.037573,0.028938,-0.053261,-0.005298,-0.042091,0.057340,0.056245,0.035093,0.049602,0.060674,-0.008304,0.047260,0.028899,-0.019972,-0.051767,-0.029988,0.020010,0.004995,0.047917,-0.040066,0.051438,0.041211,-0.027596,0.006077,-0.029537,-0.025305,-0.054404,-0.035196,-0.056788,-0.005176,0.017733,0.055795,-0.014812,-0.032462,-0.052369,-0.023498,0.019828,0.056719,-0.032819,0.057571,-0.028845,-0.052179,-0.047240,0.039482,0.041403,-0.040082,-0.028792};
  parameter real W225[0:249] = {0.016811,-0.017799,-0.040526,-0.030124,-0.014849,0.021346,-0.050015,0.031990,-0.037867,-0.028552,0.044069,-0.011517,0.052168,0.015290,0.048639,0.043743,-0.006017,-0.034796,0.037401,0.048944,0.023145,-0.050788,0.001186,0.059622,0.020501,0.039022,-0.022655,-0.007992,-0.017203,-0.055173,-0.000771,0.046355,-0.018432,0.016669,0.031542,0.027358,-0.058332,-0.001574,0.024344,0.027987,-0.000390,-0.002904,-0.007644,0.012093,0.037567,0.037098,-0.026675,0.043379,0.038222,0.048420,-0.062681,-0.017559,0.064329,0.041422,0.060641,0.029328,-0.009923,0.020094,0.012009,-0.031578,0.011999,-0.047565,-0.003631,-0.037416,-0.045417,-0.053083,0.011540,-0.040286,-0.055614,0.043101,0.052435,0.040935,0.028003,-0.012682,-0.027342,0.065983,0.036386,-0.021742,0.003688,0.043866,0.028231,-0.004587,0.022224,0.030824,-0.043232,0.061479,0.053267,0.038735,-0.061301,-0.058215,-0.044905,-0.036813,-0.017778,-0.006770,0.057984,0.020062,-0.033464,-0.012013,-0.015645,0.048399,0.009437,0.018425,-0.033139,0.028711,0.033713,-0.029970,0.020519,0.006722,-0.067211,-0.020231,-0.009843,-0.012307,-0.009015,-0.022920,0.033066,-0.036771,-0.059601,-0.032992,-0.034171,-0.040909,-0.032643,0.040036,0.065354,0.010573,-0.057005,-0.006456,-0.064803,-0.010980,0.064098,0.043998,-0.033208,-0.045765,0.049951,0.045403,0.004616,0.017283,0.057585,-0.055422,-0.035329,-0.057330,-0.053920,-0.059274,-0.021380,-0.024459,0.013147,0.044601,-0.004359,0.018330,-0.020656,-0.000588,0.002097,-0.050440,0.036491,-0.052989,-0.063098,0.021047,-0.037842,0.009319,-0.054646,-0.008961,0.030926,-0.041612,0.002050,-0.056079,0.025998,-0.043863,0.049493,-0.006730,0.058126,-0.003510,0.063579,0.036154,0.030821,-0.042034,-0.007808,0.055516,-0.032164,0.049113,0.061127,0.055162,0.031454,0.037306,-0.040814,-0.028364,0.026940,0.014971,0.051598,-0.063277,-0.036057,0.009604,0.053174,0.012453,-0.062141,-0.037820,0.047700,0.028590,-0.054336,0.006544,-0.053630,0.037969,0.060426,0.004558,0.062375,-0.051869,0.001286,0.055107,0.005096,0.037856,-0.013666,0.016573,0.018385,0.008355,-0.051880,-0.047396,-0.000148,-0.043922,-0.053704,-0.012450,0.011128,-0.017612,0.019363,-0.045167,0.028740,0.059292,-0.060003,-0.003631,-0.022093,0.013509,-0.027228,-0.014653,0.010461,-0.003632,0.016629,0.056746,-0.033136,0.030658,-0.027216,0.020566,-0.055011,0.035677,0.049774,0.022588,0.036237,-0.007902,-0.055697,0.000842,0.028238,-0.009187,0.050884,0.049418};
  parameter real W226[0:249] = {-0.063694,-0.000631,0.028785,0.050374,-0.011339,-0.008404,-0.046353,0.020245,-0.028078,0.058084,0.019261,-0.009155,-0.047285,0.045448,-0.029986,-0.062809,0.010432,0.069160,-0.046684,-0.000012,0.021554,0.025658,0.024581,-0.065723,-0.052986,0.059064,-0.014720,0.029390,-0.037384,-0.058359,0.068527,0.011954,0.001960,-0.035763,-0.043416,-0.018386,0.016848,-0.037460,-0.012104,0.011250,0.023206,0.053647,-0.021390,0.037928,0.041507,0.052050,-0.002490,-0.059510,0.038368,0.032770,-0.039534,-0.037311,-0.029702,-0.059618,0.001221,-0.008387,0.045560,-0.025176,-0.009930,0.059700,-0.031307,0.004928,0.004218,-0.038042,-0.023077,-0.013459,0.035840,-0.030573,0.041018,0.002875,0.039139,-0.016878,-0.016870,0.035983,0.000195,0.013392,-0.012100,0.048682,-0.033868,0.029875,0.055337,0.017477,-0.005035,0.039263,-0.050561,0.056374,-0.014515,-0.055149,-0.030867,0.016196,0.049907,0.015507,0.023036,0.034199,-0.046440,-0.033205,-0.033222,-0.032265,0.020293,-0.012608,-0.044580,-0.038216,0.024961,-0.050773,0.022180,0.054489,0.004579,0.039065,-0.042615,0.032515,0.004471,0.011435,0.026082,0.027512,-0.016035,0.030951,-0.014609,0.022637,0.017834,-0.011433,0.054752,0.033545,0.034474,-0.059977,0.005672,0.000924,-0.033189,0.001956,0.057908,-0.003375,0.017583,0.012215,-0.014686,-0.005702,0.037060,0.036030,0.018669,-0.009093,0.042676,-0.023646,0.011177,-0.046093,0.027689,0.018835,-0.030662,-0.004232,0.058625,0.002116,0.022206,-0.029674,-0.037177,-0.051787,0.042321,0.027119,-0.016462,0.053135,-0.027192,-0.020945,-0.008463,-0.051823,0.025642,0.040764,0.057094,-0.051670,-0.011754,-0.011959,0.013411,0.059446,0.062579,0.034165,-0.061315,0.028109,-0.002472,0.034210,-0.032345,-0.022814,0.044655,-0.009061,-0.033796,-0.022364,0.017938,0.054424,-0.035932,-0.006935,0.036135,-0.038851,0.069627,-0.013281,0.043224,-0.060554,-0.019296,0.023106,0.023023,-0.050021,0.049601,-0.005762,-0.036140,0.024980,0.045673,0.018741,0.053199,0.039300,-0.048056,0.028261,-0.021614,-0.045076,0.016170,0.055194,-0.045543,0.041611,-0.007794,0.021808,-0.048526,-0.050230,-0.018696,0.038060,-0.013732,0.027189,-0.018053,0.002897,-0.004360,-0.054240,-0.023941,0.003041,-0.015233,0.023705,-0.037708,-0.044446,-0.051740,-0.005049,0.005828,0.039655,-0.013583,-0.011991,-0.051906,0.006374,0.042380,-0.006742,0.047366,0.029492,-0.018996,-0.036260,-0.060542,0.057131,-0.041704,0.051688,-0.039967,0.060420,0.032613,-0.039983};
  parameter real W227[0:249] = {-0.032041,0.003869,-0.047831,-0.006143,-0.006503,-0.023797,0.048747,0.012012,0.040990,0.022733,0.033342,-0.060273,0.028849,-0.062615,0.017596,-0.045945,0.055440,-0.018195,0.035759,0.022080,-0.021500,-0.056304,-0.055998,0.020494,-0.022961,0.031516,-0.007691,-0.052983,-0.000159,0.052341,0.037068,0.004922,-0.050540,-0.040357,-0.052092,-0.025044,0.036280,0.053657,-0.054540,0.037525,0.033648,-0.003265,0.005841,-0.000409,-0.027784,0.057571,-0.000045,-0.016367,0.000727,0.005442,0.015002,0.058137,0.050659,0.002775,0.054671,0.020351,-0.062634,0.058107,-0.050173,0.034127,0.031273,0.050309,-0.000815,-0.053608,-0.016565,-0.004525,0.004804,0.049893,0.025516,-0.023780,-0.039399,0.033798,0.052118,-0.034225,-0.012429,-0.000060,-0.050995,-0.012227,0.007666,0.012438,0.046339,0.038045,-0.058503,-0.036390,-0.021573,-0.039435,0.020959,0.005814,-0.000172,0.037817,-0.015730,-0.055264,-0.039898,-0.050009,0.051806,-0.063630,0.046630,0.027056,-0.001487,0.043591,0.014966,0.051307,-0.037620,0.002183,0.007684,0.030619,0.062232,0.038145,0.008687,-0.021790,-0.057616,0.039683,0.064355,-0.031954,0.022653,0.022813,-0.044012,0.058081,0.061441,-0.040850,-0.056043,-0.022156,-0.044984,0.029669,-0.007612,-0.006100,-0.056436,0.062413,-0.064211,-0.047522,-0.056803,0.038934,-0.020399,0.032015,0.033712,-0.006157,0.059432,-0.046405,-0.016539,0.030494,-0.054405,-0.000201,-0.007147,-0.051497,-0.003319,-0.053982,-0.013550,0.062697,-0.049554,0.029671,-0.029648,0.012642,0.017881,-0.001198,0.010718,0.026397,0.053777,0.024995,-0.054367,-0.021715,0.030665,0.017742,-0.033951,0.019632,-0.006721,0.051817,0.027385,0.030856,-0.046343,-0.043685,-0.034419,-0.029245,0.031129,-0.039450,-0.001037,0.019090,0.012669,-0.046624,0.044029,-0.059650,0.012918,-0.019725,-0.049391,-0.045542,0.036691,0.028777,0.016428,-0.015089,0.032491,-0.036670,-0.030905,-0.039292,-0.019150,-0.016678,0.023895,0.038518,-0.034935,0.039083,-0.059488,0.031239,-0.054693,0.019827,-0.013572,-0.028193,0.054513,0.055746,-0.035513,-0.001887,-0.004045,-0.008804,-0.006817,-0.055956,0.027527,0.054530,-0.043206,-0.000374,-0.027102,-0.022047,0.021715,0.003749,-0.054964,-0.006174,0.043045,-0.028485,-0.058636,-0.016418,0.004009,0.058166,-0.040806,-0.052127,0.050765,0.043661,0.028031,-0.007345,-0.037247,0.030316,-0.021660,-0.059074,-0.023387,-0.064226,0.045989,0.035300,-0.063987,-0.030313,0.028925,0.059564,-0.016764,0.052928,-0.030269,0.033668};
  parameter real W228[0:249] = {0.034652,-0.019066,-0.058142,-0.000627,-0.055750,0.019354,-0.001849,-0.000059,-0.057020,-0.003161,-0.044407,0.040682,0.042518,-0.048589,0.029127,0.053704,-0.007365,0.059198,0.036537,0.001843,-0.024054,0.027975,-0.065733,0.009082,-0.062187,0.014954,-0.053997,-0.033234,0.021616,0.023675,-0.015364,-0.054022,0.015638,0.039861,-0.007083,-0.059665,0.001998,-0.028267,-0.028346,0.039274,-0.023293,-0.029022,0.033810,0.059587,0.057942,0.005749,-0.018930,-0.044838,-0.017144,0.054032,-0.033144,-0.024010,0.030890,0.008145,-0.013988,-0.060192,0.059777,0.053485,-0.009333,-0.032540,0.060890,-0.034177,0.044745,0.057275,0.002440,-0.024876,-0.009893,0.035615,0.035646,-0.001520,0.040043,-0.042880,0.021113,-0.047676,-0.020788,0.025837,0.004083,-0.041163,-0.008107,0.003618,-0.033902,-0.048310,0.031536,0.006666,-0.008666,-0.026149,-0.008047,0.039039,0.036439,0.018939,-0.013982,-0.058134,0.015730,0.001776,-0.062045,0.039335,0.013158,0.053750,-0.013255,-0.001530,-0.010349,0.043401,-0.041355,-0.021422,0.001538,-0.036130,-0.045840,-0.010969,-0.013412,0.045278,0.013623,-0.037773,0.052369,-0.054808,0.008671,-0.002434,-0.027044,0.050102,0.048616,0.027715,0.013009,0.017725,-0.055211,-0.009896,-0.003547,0.009884,0.045561,-0.035243,0.061119,-0.023356,0.035514,-0.028566,0.025359,0.003560,0.038623,0.019946,0.045015,0.027683,-0.065554,0.039333,-0.058913,0.012127,0.040165,-0.049126,0.048636,-0.059238,-0.053139,-0.000777,-0.026405,0.055101,-0.036714,0.050887,0.003378,-0.047883,0.025606,0.043805,0.040362,-0.020225,-0.060540,0.034954,-0.047728,0.053374,-0.007949,0.006665,0.016043,0.021386,-0.009941,0.038824,0.016190,0.053469,0.031542,0.050336,0.018525,-0.045984,0.020405,-0.002551,-0.009688,-0.029170,-0.057795,0.016685,0.022912,0.025071,0.001076,0.002568,0.001309,0.053993,-0.013792,-0.018552,-0.015510,-0.051942,-0.002099,-0.061152,0.039675,0.008817,-0.041675,0.002870,0.002035,0.044987,0.007024,-0.065247,0.024425,0.062064,-0.042179,-0.032175,0.054838,-0.028276,0.024691,0.050212,-0.032781,0.038256,0.003672,-0.015419,-0.010673,-0.021325,-0.049498,-0.061834,-0.030300,-0.047641,0.047960,-0.058794,0.062056,0.001775,-0.003050,0.029364,-0.004202,-0.006567,-0.025446,0.030341,-0.023116,-0.002632,-0.004804,-0.018868,0.015694,0.054516,0.022894,-0.027745,-0.048884,-0.020431,0.019398,0.056566,-0.055109,-0.058557,-0.039662,0.040192,-0.007448,-0.051009,0.059287,0.020682,-0.032894,0.055195};
  parameter real W229[0:249] = {0.001672,0.034321,-0.024378,-0.043669,0.001136,0.005688,0.049390,-0.053972,0.058780,0.060141,-0.035477,0.051894,-0.003969,-0.058538,-0.024440,0.024122,-0.050299,-0.055788,-0.020206,-0.054778,-0.035902,0.046459,0.014689,-0.006823,0.002842,-0.018468,-0.013479,-0.008091,-0.031264,0.020257,-0.046175,-0.005781,0.038611,-0.031961,-0.046705,0.026529,0.062850,-0.047235,0.058290,0.056561,0.025084,0.047770,0.061818,-0.001970,0.063406,-0.016856,0.046185,0.028881,-0.037043,0.004036,0.021707,0.047755,-0.052734,-0.054970,0.041479,-0.027495,-0.022731,0.010432,-0.019222,0.021587,0.018482,0.000480,0.038801,-0.031613,0.033613,-0.060434,-0.055022,-0.061703,-0.033821,-0.021407,0.044121,-0.042553,-0.016975,0.040065,0.031727,-0.006396,0.054715,0.030886,-0.025816,-0.049116,-0.055217,-0.045422,-0.016098,0.046334,0.004735,-0.058804,0.039983,-0.016875,0.025496,0.032592,0.043046,0.045572,0.027573,0.053533,-0.009470,-0.002292,-0.015887,0.028391,0.040824,-0.004317,-0.038412,-0.055229,0.044590,-0.030917,0.011684,-0.017788,0.034805,-0.031131,-0.026603,0.023554,0.012047,0.026221,-0.027940,-0.028172,0.039287,0.036423,0.061356,0.005296,0.015547,0.002027,-0.005136,0.014097,-0.008459,0.052751,0.025226,0.020338,0.044155,0.023914,-0.038902,-0.007164,0.060444,-0.009959,-0.040497,0.001879,0.013174,0.039609,0.038069,-0.038327,0.053987,-0.018399,0.004225,0.029459,0.012424,-0.053486,0.001125,0.064526,-0.054256,-0.049424,0.027255,0.033794,0.017386,0.032508,-0.017752,-0.041607,0.022677,-0.000953,-0.001153,-0.016746,0.037438,0.014929,0.054254,-0.025829,-0.005914,0.020869,-0.013949,0.063875,-0.064419,-0.047856,-0.059612,-0.033168,0.061926,0.037684,-0.044576,0.055281,-0.036445,-0.058505,0.055641,0.042934,-0.039086,0.018791,0.005561,0.037980,-0.037522,0.046600,-0.056002,0.015683,0.051989,-0.001418,0.054980,-0.018224,0.035777,-0.004254,-0.027858,-0.029263,-0.020910,-0.021847,0.003978,-0.031838,0.026187,-0.023343,0.014704,-0.022524,0.053630,-0.010225,0.055611,0.020713,-0.056849,-0.017154,0.043410,-0.029478,-0.060140,0.050751,-0.039673,-0.001896,-0.004752,-0.041276,0.053626,-0.017858,-0.065494,-0.003432,0.008135,-0.009855,-0.008814,0.031947,-0.014953,-0.051761,-0.003160,0.003004,-0.029011,-0.056048,-0.040382,-0.054834,0.037884,0.053980,-0.042291,-0.000460,-0.026182,-0.048872,0.046956,-0.059725,-0.033204,-0.041896,-0.002667,0.021550,-0.026411,0.005857,-0.046514,-0.034352,0.034754,0.024821};
  parameter real W230[0:249] = {-0.044453,-0.013074,0.014849,-0.001042,-0.048885,-0.057516,-0.046437,-0.067011,-0.050891,0.043970,0.027889,-0.058071,0.056653,-0.001363,-0.047021,0.035527,-0.019465,-0.042050,0.017383,0.042687,0.035248,-0.048264,-0.056811,-0.046505,0.023100,-0.041983,0.022625,-0.065918,-0.007987,-0.005680,0.022959,0.027380,-0.016774,-0.057591,-0.022031,-0.042829,0.025716,0.009304,-0.013234,-0.048086,0.022854,-0.001123,-0.019915,0.015182,0.028747,0.005855,-0.034792,-0.032824,-0.059809,-0.022721,-0.040081,-0.029412,0.043804,0.006497,0.002337,-0.034176,-0.016991,0.026830,0.008207,0.048641,0.060324,-0.007068,-0.031552,0.024083,-0.038431,0.005358,0.032271,0.019425,0.073387,-0.003382,0.062419,-0.060294,0.002991,0.046048,0.046879,-0.000301,-0.020940,-0.053596,-0.045099,0.009926,-0.033608,-0.029476,0.009013,0.016429,0.000157,0.035455,-0.023181,0.025025,0.001143,0.038393,-0.021886,-0.015006,0.056131,-0.011395,0.002781,-0.074789,0.064613,-0.044629,-0.060643,-0.033758,0.041546,0.046689,0.035728,-0.015365,0.045847,-0.055397,0.062015,0.064695,-0.002392,-0.063747,0.014662,0.062630,-0.019684,-0.005258,0.026711,-0.043089,-0.009421,-0.007353,0.026474,0.004431,0.011568,0.003892,0.030378,0.046727,0.014342,0.049551,-0.040524,-0.037538,-0.007362,0.063457,0.023630,-0.035837,-0.046869,0.008005,-0.057854,-0.020251,0.052260,0.025337,-0.016484,0.024523,0.047670,0.060375,-0.044467,0.046057,-0.007838,0.044103,0.020161,-0.006327,-0.042427,0.058444,-0.011139,0.030452,-0.079789,0.046832,0.056440,-0.022092,-0.031028,0.032435,0.031024,-0.060464,-0.055409,-0.007417,-0.021658,0.064210,0.045021,0.058984,-0.011385,-0.004883,0.035876,-0.053695,-0.049529,0.004662,0.028600,-0.031001,-0.030829,-0.053198,0.041158,0.000119,-0.060624,-0.052979,-0.017889,0.013501,-0.044349,-0.052868,-0.015173,0.053918,-0.066682,-0.047903,-0.056269,0.046083,0.030979,0.007116,0.057144,-0.017387,0.006931,-0.052608,0.000840,0.039699,0.053487,-0.075972,0.008574,-0.017472,0.008477,-0.060871,0.000789,0.033396,-0.045893,-0.030029,0.051693,0.046951,0.050394,0.005384,-0.058874,0.033189,-0.056946,-0.043857,0.005110,-0.014470,0.016656,-0.001389,0.009707,0.020564,-0.043345,0.036423,-0.054333,0.031307,-0.019374,-0.036939,0.051281,0.013192,-0.013610,0.050784,0.049241,0.018917,-0.011920,-0.001829,0.009461,-0.035268,-0.007768,-0.038891,-0.001802,0.015547,0.049901,0.037445,-0.012300,-0.003908,-0.055969,-0.057334,-0.006846,0.061981};
  parameter real W231[0:249] = {0.040156,-0.021579,-0.024014,-0.009931,-0.005379,-0.056769,0.039246,-0.031387,0.036991,-0.041397,0.018001,-0.025166,0.032569,-0.067522,-0.001715,0.038879,-0.002699,0.050949,-0.035693,0.010442,-0.010575,-0.047225,0.024466,-0.001548,-0.012456,-0.020698,-0.067156,-0.034368,-0.052801,-0.054245,0.001987,-0.066171,-0.011870,0.025539,0.083450,0.063854,0.041418,0.064238,0.074592,-0.013398,0.048867,-0.044038,-0.053242,0.012891,-0.067696,-0.037909,-0.040630,-0.027424,0.005199,-0.028022,0.049550,0.004344,-0.029009,-0.044490,-0.006703,-0.061202,0.047846,0.040661,0.028045,0.057093,0.031570,-0.045930,-0.036701,-0.026462,-0.041787,-0.053956,-0.048347,0.060192,-0.026798,-0.007477,-0.066314,0.063454,0.011367,-0.035667,-0.037320,0.066256,-0.010231,0.064010,0.000334,0.001281,0.044674,0.033630,0.048306,0.043703,0.025816,0.008890,0.017330,0.010764,-0.013166,0.026250,-0.046977,-0.004797,-0.025043,-0.005329,0.012696,0.058034,0.061362,0.048758,0.051374,-0.030475,0.048918,0.018168,0.067513,-0.040562,-0.065088,0.049770,-0.061279,-0.034693,-0.025774,-0.012623,-0.035205,-0.025223,0.026595,0.026033,0.059944,-0.023716,-0.004377,0.010208,0.056765,-0.040984,0.045581,-0.028789,0.057626,-0.056708,-0.000406,-0.011122,-0.039700,-0.028319,0.060230,-0.005849,0.030027,0.041595,-0.037078,-0.001810,0.054157,0.046699,0.079115,-0.023744,-0.038290,0.054870,0.054040,0.033860,-0.020554,-0.022001,0.037829,-0.060324,0.033648,-0.018686,0.060302,-0.013824,0.026299,0.015124,0.023486,-0.068344,0.022248,-0.051707,-0.017976,0.021692,0.053089,0.017997,-0.009458,-0.035398,0.003870,0.002816,-0.010741,-0.003844,-0.005740,0.074277,-0.002890,0.003083,-0.051735,-0.059425,-0.000877,-0.023373,0.038461,0.006788,-0.080441,-0.000704,-0.055907,0.004261,-0.009303,-0.016902,0.046518,-0.052103,0.045588,0.055750,-0.011391,0.008418,-0.015624,-0.018302,0.009511,-0.039172,0.003928,0.007842,0.037842,0.017381,0.026828,-0.048174,0.021988,0.054735,-0.021259,-0.039476,-0.066873,-0.058417,-0.011819,0.041633,-0.052954,-0.038579,-0.005128,0.056910,0.000677,-0.026685,0.046969,0.015473,0.056863,-0.009681,0.044670,0.006471,0.009622,0.041537,0.013255,-0.071402,-0.020331,0.009458,0.006405,-0.048136,0.063646,0.034999,0.053159,0.010767,-0.071813,-0.039493,-0.051242,0.014985,0.032268,-0.053829,0.021311,0.056271,-0.024464,-0.059606,-0.013172,-0.038403,0.014922,-0.012620,0.049672,-0.011034,0.015167,0.019976,-0.002431,-0.049746};
  parameter real W232[0:249] = {-0.018634,-0.070715,-0.025275,-0.013756,-0.052517,0.031866,-0.001910,-0.038480,-0.010914,0.031020,-0.047885,-0.025269,-0.054906,-0.021317,0.021963,0.014391,0.017317,0.008290,0.058143,-0.044152,0.058525,0.003849,-0.032348,-0.038740,-0.027300,-0.007576,0.027932,-0.012615,-0.045361,-0.044359,-0.050077,0.050948,-0.044780,-0.044533,-0.007130,0.053339,-0.046895,0.045071,0.059497,-0.013870,0.035066,0.001687,0.007870,0.064576,-0.042789,0.062625,-0.056526,0.017342,0.029648,0.003708,-0.065141,0.051100,0.081786,0.053663,-0.014275,-0.016351,-0.053447,0.031392,0.040495,0.076921,-0.024592,0.043480,-0.024234,0.026801,-0.020376,-0.041060,-0.044447,-0.031083,-0.070981,0.023331,-0.057207,-0.028216,-0.047842,0.003385,-0.039947,0.083526,0.021783,-0.046992,-0.004497,0.026844,0.020840,-0.046674,-0.029466,-0.013763,-0.047213,-0.046739,0.025236,-0.067814,-0.002650,0.022188,-0.034875,0.026653,0.011015,-0.032789,-0.008055,0.008447,-0.014205,-0.000476,-0.011153,0.048916,-0.006591,0.003288,0.014954,-0.012690,-0.036000,0.023784,-0.096057,0.029252,0.010246,-0.006691,0.058477,-0.052716,0.013642,-0.008213,-0.039642,-0.052453,-0.085529,-0.051376,0.029637,0.046179,0.031235,-0.032544,0.052226,-0.062032,0.017511,-0.030806,0.021893,0.004325,0.020987,-0.055222,-0.036721,-0.055955,-0.025698,0.064379,-0.019266,0.061054,0.062448,0.040586,-0.024073,-0.018402,0.021878,0.032629,0.026004,0.026065,0.047459,-0.059911,0.041222,0.018628,-0.026825,0.019766,-0.004573,-0.049747,0.069218,-0.072235,-0.014299,-0.016145,0.066990,0.010512,-0.037293,0.004689,0.026486,0.016380,0.002200,0.020459,-0.008717,0.034474,-0.027539,0.025251,-0.055976,0.071035,-0.032005,-0.053246,0.039337,0.020175,-0.020096,0.037735,0.014880,-0.010180,0.029260,-0.013463,-0.012749,0.046145,0.042123,-0.000374,0.026913,-0.025396,-0.020669,-0.015244,0.021790,0.024447,-0.026315,-0.081836,0.003886,0.006959,0.096016,0.027941,-0.059709,-0.051843,0.038710,0.020267,-0.006852,-0.038376,0.052897,-0.058391,-0.051136,0.001277,0.001095,0.059838,0.036899,0.059980,-0.015624,0.007253,-0.067403,-0.016934,0.018078,0.012273,0.015539,-0.023539,0.015124,0.026529,0.001594,-0.054972,-0.044312,0.011726,-0.057793,-0.010655,0.001200,-0.005978,0.006961,0.042110,0.049375,0.027131,-0.047693,0.056700,-0.024945,0.068759,-0.064462,0.036874,-0.055909,0.015847,-0.081794,-0.083412,0.039242,0.048702,0.041880,0.038714,-0.003937,0.032545,-0.061202,-0.041005};
  parameter real W233[0:249] = {0.048943,0.006354,-0.017583,-0.048497,0.001945,-0.063633,-0.020211,0.012551,-0.054123,0.024663,-0.038089,-0.002534,-0.028340,-0.052350,-0.005662,0.033966,0.009406,-0.028809,-0.004917,-0.019099,-0.017076,-0.034641,0.050709,0.046795,-0.051083,-0.051412,-0.016103,0.023024,-0.044119,-0.040909,-0.019397,-0.011046,0.041099,-0.027961,0.002330,-0.025173,-0.008195,0.046537,0.020659,-0.045122,-0.066752,-0.061571,0.045632,-0.034825,0.030778,0.034478,-0.026160,0.041624,-0.050547,-0.006430,-0.052036,0.048210,-0.013697,0.018624,-0.031007,-0.038386,-0.025494,0.045059,0.036183,0.010893,0.011680,0.012976,-0.013655,0.060887,0.038514,0.028252,-0.057387,-0.009141,-0.051959,-0.041943,0.044161,0.001367,-0.016206,0.066670,-0.047962,0.014871,0.001910,0.031810,-0.046900,-0.019434,0.061338,0.017782,-0.025205,-0.032711,-0.057337,0.012107,-0.043554,0.031308,-0.027542,-0.006013,0.001732,0.039868,-0.056720,0.049435,0.002356,0.029443,0.000326,0.056094,0.053920,0.014191,0.050623,0.001517,-0.020346,-0.027495,0.023812,-0.051713,-0.057809,-0.062021,-0.025603,0.029637,0.014344,-0.023355,0.001030,0.010323,0.003240,-0.026691,-0.047244,0.033337,-0.011577,0.019169,0.062379,-0.013751,0.039997,-0.020657,-0.051788,0.039171,-0.039461,-0.019703,0.006826,-0.011541,0.058113,0.050111,0.002190,0.036224,0.017949,0.000868,-0.031598,-0.042942,0.041882,-0.052713,-0.048619,-0.000140,0.050270,-0.038629,-0.014770,-0.064112,0.006782,-0.023244,0.054629,0.043526,0.022180,0.013622,0.010284,0.030844,0.008426,-0.063101,-0.033850,0.023880,0.019149,0.056844,0.011908,-0.072331,0.033185,-0.009001,-0.061919,0.023942,-0.059921,-0.008602,0.005934,-0.022366,-0.032280,0.011703,0.010110,0.040652,-0.017273,0.012103,0.026952,-0.052351,-0.039244,-0.063355,0.046896,0.035502,0.018403,-0.054577,-0.060438,0.060744,0.054706,-0.045151,-0.029226,-0.054817,0.028381,0.035848,0.007922,-0.008975,0.013891,-0.018769,-0.051743,-0.013791,-0.007324,-0.022463,0.010575,0.031616,-0.017016,-0.052461,-0.009638,-0.037826,0.033869,-0.019683,0.056092,0.063995,-0.010026,0.019264,0.044494,-0.007852,0.020095,-0.006003,-0.040776,0.042741,0.036137,0.055313,-0.004068,0.002680,-0.041064,-0.008248,-0.048409,0.054687,0.007192,-0.028294,-0.030149,-0.015159,0.018446,-0.001133,-0.041063,-0.007557,-0.007663,-0.034038,-0.034700,0.023013,0.056144,-0.014184,0.008283,-0.010986,-0.053300,-0.057968,0.043188,-0.059559,-0.060966,-0.058712,0.032548,-0.063228};
  parameter real W234[0:249] = {0.050369,-0.018740,0.024420,-0.008169,-0.047415,0.029347,-0.027190,0.041150,0.014056,-0.028554,-0.044137,-0.057898,-0.041872,-0.030132,-0.064067,-0.015565,0.042182,-0.016682,-0.006516,0.058831,0.034773,-0.019679,-0.025856,0.027535,0.054872,-0.025614,0.027016,-0.055299,0.015606,0.037091,0.049765,0.019979,-0.061190,0.028469,0.012495,-0.017805,0.027354,-0.040554,0.008268,0.011795,0.057860,0.007829,-0.029697,0.065340,0.016664,0.042413,-0.059925,0.016876,0.054486,0.037466,0.023282,-0.035213,-0.001524,-0.052903,0.048270,0.046025,0.000993,-0.000114,-0.034905,-0.018138,0.042578,0.063565,-0.006226,-0.048672,0.000860,-0.006784,-0.023175,-0.036761,0.040547,-0.026624,0.020311,-0.046258,0.015186,-0.057749,0.036330,-0.057765,-0.036840,0.002580,0.014142,-0.019762,-0.037583,-0.061119,-0.056495,-0.030700,0.007520,0.039685,-0.006161,-0.029205,-0.043648,-0.025311,0.026723,-0.034036,0.028121,0.054683,-0.019702,0.049455,0.014337,-0.013092,0.053853,-0.014905,0.005547,-0.046665,0.051861,0.002515,0.037374,0.037141,-0.045233,0.015757,0.045238,-0.052415,0.061263,-0.059917,-0.041664,0.023547,-0.046420,0.049606,-0.050980,-0.031865,-0.049907,0.041838,-0.058856,0.034925,-0.018800,-0.023578,0.035175,-0.042030,0.059238,0.039026,-0.038280,0.028692,0.058705,0.037225,-0.000781,-0.008364,0.051554,0.013481,0.018750,-0.002323,-0.055844,-0.008196,0.006934,-0.011594,0.008141,-0.030878,0.054770,0.040993,-0.037521,0.007644,-0.008487,0.034905,0.006554,0.045573,-0.011520,0.031426,0.025731,-0.014748,0.049577,0.047696,-0.027316,-0.029997,0.042818,0.057890,0.053016,-0.017536,0.013391,-0.043966,0.021340,-0.032942,-0.028672,-0.040758,-0.053035,0.029145,0.025647,0.014583,0.060524,0.013511,-0.059046,0.039474,0.048377,0.025852,0.017373,0.042235,-0.001128,-0.012094,-0.027416,-0.044269,-0.031163,0.026646,-0.015872,0.033608,-0.028277,0.048482,-0.061397,0.025620,0.056988,0.039883,-0.007069,-0.027472,0.042245,0.030639,-0.035042,-0.048100,0.024796,0.012820,-0.024686,0.020368,0.024203,0.056587,-0.029058,0.008547,0.048330,0.055785,-0.047273,0.017871,-0.054121,0.047837,-0.005294,-0.019009,0.020379,-0.036281,0.028544,-0.029359,-0.036811,-0.041150,0.059279,-0.052753,0.044776,0.029865,0.061107,0.056455,0.013622,0.018006,0.006798,-0.030219,0.019835,-0.031602,-0.049265,-0.011415,0.052522,-0.025586,-0.038496,0.003000,-0.028142,0.036046,0.060553,0.006099,-0.002040,0.020408,0.058678,0.002939};
  parameter real W235[0:249] = {-0.065095,-0.058172,-0.005979,-0.034571,-0.053815,-0.026317,-0.017897,-0.024079,-0.012790,-0.022941,-0.060039,0.047166,-0.046372,0.025173,0.019136,0.043111,-0.006163,-0.059652,0.035154,-0.015850,0.000711,-0.023697,0.046896,0.026308,-0.005654,-0.060034,0.034969,-0.008070,-0.014933,-0.047286,-0.058904,0.010537,-0.044663,0.041399,0.054838,-0.033723,0.008694,-0.050549,0.031866,-0.054422,0.011981,0.001815,-0.041456,-0.011966,0.046600,-0.041492,-0.054032,0.040989,-0.035732,0.064343,-0.045573,0.021254,0.044958,-0.052678,0.008446,-0.002917,-0.019496,0.052605,-0.019413,0.059241,-0.063346,-0.022201,0.003639,0.004112,-0.056196,0.016620,0.002231,-0.054696,-0.007593,-0.039307,0.005576,0.023545,-0.028309,0.017461,0.007117,0.011956,0.019327,0.012146,0.025769,-0.049621,-0.033177,0.016902,-0.002480,0.055732,-0.040837,0.015503,0.049902,0.056660,-0.010019,-0.011866,-0.032991,0.045468,0.019400,0.057611,0.044411,-0.037957,-0.055168,-0.022455,0.062057,0.036886,0.060680,-0.028190,-0.033918,-0.028262,-0.062701,-0.011392,-0.029505,0.051487,-0.029895,0.003015,0.033721,0.055200,-0.028961,-0.047050,-0.062802,0.009523,0.056748,-0.060282,-0.027408,0.066468,-0.048178,-0.013372,-0.054831,-0.038818,0.053954,0.046081,-0.026973,0.053955,0.055206,-0.028265,-0.047472,0.046083,0.011775,-0.040565,0.044917,0.031245,0.007862,-0.035946,0.023223,-0.013145,-0.052055,-0.006435,-0.031872,0.004052,0.022866,0.032267,0.026808,0.043329,-0.048535,0.018552,0.048155,-0.020001,-0.028679,-0.061500,-0.050891,-0.007757,0.067849,-0.031067,0.033388,-0.050762,0.030691,0.049048,0.063427,-0.042535,0.035437,0.001206,0.062549,-0.005130,0.059523,-0.040405,-0.031807,0.036545,0.017320,-0.039190,-0.026172,0.010761,-0.022212,0.057374,0.036198,0.052512,-0.042228,-0.001354,-0.018171,-0.044069,0.054418,0.027363,0.012811,-0.064241,0.045038,-0.042836,0.053668,0.019901,-0.005370,-0.009011,0.027054,0.003681,-0.041192,-0.035927,-0.019041,-0.018049,0.047166,0.022184,0.020776,0.015123,0.000533,0.036856,0.052752,-0.008021,-0.015155,-0.005117,-0.055655,-0.008972,0.037394,-0.021422,-0.004280,-0.053197,0.055835,0.005911,-0.049064,-0.049279,-0.033850,0.049231,0.056742,-0.029108,-0.005742,0.020598,-0.005443,-0.064558,0.035967,0.050555,-0.061503,0.029897,0.057219,0.022333,0.026326,-0.019877,0.016150,0.008344,0.010200,-0.014009,-0.021457,0.034118,-0.058150,0.008872,0.060241,-0.023347,-0.021570,0.017089,-0.031827,-0.014165};
  parameter real W236[0:249] = {0.043597,0.062752,-0.000838,0.050289,0.044660,0.000075,0.023887,0.061120,-0.003713,-0.047919,-0.040258,-0.002338,-0.041201,0.006397,0.053049,-0.035164,0.022036,-0.001232,-0.014506,-0.000498,0.055294,0.030715,0.035929,-0.046564,0.038357,0.002927,-0.013744,0.018845,0.051804,0.030540,-0.002352,-0.055775,-0.010561,0.015321,0.042303,0.016297,-0.005752,0.007573,-0.025722,-0.007365,0.024062,-0.037944,0.016001,-0.006700,-0.053939,-0.044839,0.011943,0.022734,-0.031548,-0.043747,-0.003311,-0.036340,-0.010786,0.044825,0.002822,0.041348,-0.015831,-0.036402,-0.043230,-0.033945,-0.063288,-0.034161,-0.032724,-0.008035,0.060504,-0.050178,-0.029757,-0.009988,0.031349,-0.008929,0.044415,-0.045041,-0.016017,-0.055387,0.038397,0.049107,0.005822,0.052975,-0.048719,-0.043305,0.002384,-0.048279,0.005013,-0.012562,0.043581,0.038495,0.000016,-0.054215,0.024838,0.056856,0.015222,0.001722,-0.025536,-0.050918,0.030155,-0.056962,-0.018459,-0.038403,-0.030795,-0.045885,0.032861,-0.053671,0.000377,0.019975,0.049487,-0.034180,-0.030741,0.041632,0.005463,-0.032022,-0.001290,0.013618,-0.005700,-0.008570,-0.046751,0.006374,-0.037773,0.048073,0.056665,0.017602,0.028643,-0.016797,0.020756,0.038072,0.024042,0.034176,0.021471,0.056344,0.028712,-0.037485,-0.051982,-0.043605,0.049598,-0.056748,-0.019298,-0.028510,0.009754,-0.056611,0.017112,0.060925,-0.061484,0.018353,0.018535,-0.020978,0.022184,-0.062269,-0.050949,0.016095,-0.056159,-0.047643,-0.034119,0.000276,0.048757,-0.043475,0.037630,0.032386,-0.042483,-0.022997,0.013600,0.062753,0.009607,-0.002683,-0.052796,0.037555,-0.035069,0.023076,0.050760,0.060879,0.008006,0.053493,0.036912,0.012862,-0.008074,0.036858,-0.017848,-0.043812,0.038578,0.051322,-0.024139,-0.046395,-0.046075,-0.041430,0.001121,0.041602,-0.037945,-0.019161,-0.062044,-0.012628,-0.030146,0.057184,-0.050331,-0.011102,0.058594,0.032634,0.043494,-0.053864,-0.034889,0.017633,0.047228,0.023603,0.021376,-0.005434,0.001582,0.023810,0.036411,0.014094,0.021876,-0.008247,-0.019923,-0.016075,-0.057018,-0.034619,-0.049293,0.021176,-0.041387,0.010674,-0.001835,0.016436,0.058431,0.061694,-0.032040,0.016022,-0.026758,-0.023045,-0.001128,-0.031474,-0.009760,-0.045924,0.050394,0.048420,0.038219,-0.031861,-0.009079,0.013969,-0.049670,0.032707,0.002761,0.013737,0.007793,0.049255,0.040985,0.004703,-0.028009,-0.051712,0.006379,0.005443,0.007514,0.036968,-0.037313,0.013055};
  parameter real W237[0:249] = {0.062124,-0.065774,-0.028614,0.002749,-0.016670,-0.041498,-0.064043,0.045735,0.014987,0.031226,0.018650,-0.040333,-0.062598,-0.028696,-0.016523,-0.062305,-0.037462,0.015332,0.039026,-0.050407,0.000089,0.001904,-0.006628,-0.021887,0.036237,0.031970,0.048797,0.026998,-0.050677,0.049396,-0.049829,0.026400,0.040069,0.026580,0.039468,-0.018080,-0.028857,-0.019063,0.047982,-0.055131,-0.029513,0.058280,-0.039690,0.060449,0.033958,-0.055526,-0.062153,0.043772,-0.026242,-0.022635,0.010627,-0.015780,-0.007443,0.063471,0.061934,-0.052527,-0.035305,0.061331,-0.064536,0.032662,-0.053753,-0.053209,0.052791,0.047243,0.001673,0.043522,-0.000958,0.006849,0.012891,-0.012449,-0.008368,-0.053268,0.009138,-0.014672,-0.054857,0.062708,-0.034238,-0.048398,-0.041676,-0.040249,0.016353,-0.029571,-0.024565,0.022929,0.007208,-0.043669,0.054461,-0.029721,0.014688,0.022257,-0.000444,-0.051673,-0.009412,-0.004534,-0.021170,0.014220,-0.050471,0.011394,-0.060720,-0.048479,0.030359,-0.059708,0.032235,0.028228,0.014853,0.012818,0.040616,-0.040104,0.005919,0.034060,0.058515,0.035319,-0.053145,0.006881,-0.016284,-0.059520,-0.044169,0.044361,-0.013409,-0.032636,0.002516,-0.026536,0.011341,-0.043562,-0.058347,0.057565,-0.000259,0.054919,0.067850,-0.030693,0.028554,-0.063609,-0.021672,0.010145,0.048780,0.025273,0.024332,0.052941,-0.031446,-0.020815,-0.045985,-0.050936,0.019443,-0.016106,-0.033896,-0.012719,0.043512,-0.051251,-0.007527,-0.047032,-0.002085,-0.046849,0.000599,-0.032749,0.025586,0.010276,-0.034476,-0.059734,0.053124,-0.010460,0.024643,-0.042488,-0.041988,0.001061,-0.052482,-0.018226,0.004997,-0.006717,-0.054661,-0.006275,-0.002847,-0.065041,-0.016383,0.006959,-0.042511,0.013291,0.019163,-0.041131,-0.025220,0.039162,-0.033195,0.006974,0.042270,-0.010708,-0.046230,0.060697,-0.045410,-0.071983,0.055251,0.043152,0.002492,-0.053023,0.045295,-0.010484,-0.033259,-0.000502,-0.025682,0.010900,0.031185,0.056721,0.056884,-0.012396,-0.019195,-0.022267,-0.053054,-0.039928,0.002036,0.002820,-0.060037,0.025639,-0.066018,0.061892,-0.043841,0.024906,-0.025805,0.004601,-0.036361,0.014442,0.012468,0.060919,0.006104,-0.019730,-0.021330,-0.004953,0.060197,0.029388,0.042426,-0.058692,-0.023242,-0.007359,0.044513,0.040687,0.005910,0.055396,-0.001691,-0.004552,0.055148,0.025799,-0.033912,-0.046294,0.022008,0.000274,-0.023452,-0.000056,0.046757,0.060820,0.044087,0.067162,0.059063,-0.035089};
  parameter real W238[0:249] = {-0.043182,-0.053804,-0.053255,0.051870,-0.045295,-0.009625,-0.013289,0.030149,0.064612,0.060848,0.055855,0.004611,-0.059547,-0.054798,0.049325,0.007070,0.007789,0.023860,-0.035455,-0.017308,-0.018554,-0.015055,-0.004491,0.051179,-0.059014,0.021570,0.020679,-0.041235,0.015486,0.023320,-0.010018,0.049811,-0.035704,-0.008768,-0.026047,-0.039021,-0.040578,-0.009647,-0.039869,-0.041275,-0.051818,0.048052,-0.061461,-0.016440,0.039679,-0.025986,0.047160,-0.014474,0.018953,0.016461,-0.061111,0.028630,-0.047636,0.029846,0.037083,-0.032045,-0.005212,0.009907,0.031455,-0.004116,0.000735,-0.051037,0.011391,-0.039246,0.042512,0.041371,0.007111,0.058930,0.045693,-0.049567,0.005300,0.015126,-0.004071,0.031806,0.043401,-0.003344,-0.034853,0.029403,0.028753,-0.038817,0.015469,0.040447,0.034226,-0.028266,0.016238,0.031324,-0.058562,0.040605,0.013029,0.030202,0.051802,-0.006449,-0.040276,0.059896,-0.030966,0.040790,-0.030222,0.058284,-0.007060,0.030183,-0.046029,0.060382,-0.019314,0.059685,0.040967,0.006881,0.026974,0.026087,-0.047374,0.005314,0.026074,0.025842,-0.037793,0.052515,0.055688,0.057469,0.024633,0.030529,0.020840,-0.006019,0.015745,0.000827,-0.048262,-0.040227,0.021635,0.037093,0.022613,-0.005740,0.006457,0.024583,0.004201,-0.017215,-0.035365,-0.060741,0.018430,0.039591,0.030676,0.054407,-0.016488,0.012775,0.036203,0.025546,0.023874,-0.030609,0.006458,0.052669,0.033032,-0.058145,0.012794,0.054807,-0.019012,0.039445,-0.003074,0.058051,-0.005832,-0.024311,-0.007558,-0.023995,0.014856,-0.055435,0.033291,0.027054,-0.038283,-0.047714,0.009368,0.020747,0.059251,0.018695,0.004521,-0.007801,-0.012456,-0.042104,0.041399,-0.033741,0.028470,0.017968,-0.022578,0.021097,0.028751,0.047092,-0.001849,-0.031772,0.052112,-0.007140,-0.028643,-0.028071,-0.003802,-0.011184,-0.028317,-0.029562,0.000739,-0.043279,0.014106,0.059857,-0.019876,-0.020564,-0.044707,-0.045520,0.054131,0.028178,-0.031191,0.036643,0.045973,0.010631,-0.058578,0.006176,0.010696,-0.039815,-0.037466,-0.058289,0.047076,-0.042590,0.036115,-0.023425,0.029494,-0.029817,0.018559,0.020686,0.024380,0.016739,-0.044466,0.033160,-0.023664,0.052846,0.048276,-0.030827,0.059353,0.041530,0.033763,0.017299,0.046096,0.052003,-0.062373,0.023128,-0.008770,0.039125,-0.014201,0.051867,0.001668,0.038404,-0.029910,0.005636,0.027286,0.066271,-0.016926,-0.013775,-0.053714,-0.022485,0.056684,0.060338};
  parameter real W239[0:249] = {-0.024391,-0.033258,-0.057520,0.050470,0.030119,-0.019272,-0.005073,-0.033868,-0.051085,0.029918,0.044712,-0.017584,-0.024514,0.000414,-0.056642,-0.028724,0.033058,0.012811,-0.013984,-0.065386,-0.007239,0.006189,-0.021746,-0.035197,0.048414,0.051861,-0.028858,-0.039686,-0.024908,-0.018598,0.041912,0.033064,-0.002342,0.004578,-0.044507,-0.059202,-0.018351,-0.055403,-0.023851,-0.014829,0.034603,-0.031846,-0.058039,-0.043310,-0.005958,-0.043943,-0.058476,-0.001152,0.075141,-0.027157,-0.006168,0.023462,0.019524,0.002430,-0.012695,-0.026413,0.031167,0.013313,-0.043351,0.038300,0.046396,-0.022571,-0.001660,-0.039332,0.006399,0.046700,-0.049538,-0.006251,-0.003310,0.025948,0.030672,-0.018037,-0.053390,0.034523,-0.056426,0.049295,-0.061443,-0.008419,0.026584,0.019412,-0.022365,0.002268,-0.055576,0.020156,0.027432,0.014227,-0.043651,-0.063826,-0.005096,-0.000414,-0.017100,-0.005115,-0.035504,0.004093,-0.012659,-0.049242,0.019926,-0.021712,0.039615,-0.015297,-0.052365,0.026733,-0.053869,-0.013924,-0.018817,-0.062736,-0.068505,0.040132,-0.001691,-0.051428,-0.050088,0.008656,-0.029577,0.040061,-0.018880,-0.008362,-0.061210,-0.044229,0.045370,-0.034163,0.045822,0.036817,-0.038851,0.037637,0.010914,-0.010350,0.037704,0.067519,0.063701,-0.013879,0.020895,-0.016362,-0.059202,0.011206,-0.049968,0.041927,-0.009082,-0.025875,-0.034465,0.013849,0.055945,0.001131,0.045884,0.002808,0.031978,0.024781,0.019151,0.026674,0.037436,0.001268,0.063698,-0.006113,-0.031905,0.007320,-0.034773,0.051012,-0.005326,-0.009622,-0.048108,-0.052876,0.013209,-0.010767,0.028463,0.043226,0.049187,0.026299,-0.048077,0.031568,0.028739,0.001693,-0.018184,0.004573,0.050881,0.030756,0.003441,-0.036099,0.015729,0.049025,0.028031,0.013822,0.007088,-0.047498,0.013907,-0.005655,-0.064934,0.048279,0.072787,0.001586,0.036907,-0.040677,-0.016142,-0.014111,0.028315,0.019616,0.065233,-0.032119,-0.054784,0.044452,-0.068635,0.053307,-0.000053,0.033145,0.004837,-0.037502,-0.058694,-0.034839,0.050811,0.040437,0.035224,0.032045,-0.002085,-0.009464,-0.051051,-0.055180,-0.038945,0.054987,-0.011552,-0.053767,-0.037275,-0.009622,-0.024048,0.023181,0.006527,0.032486,0.008770,0.055533,0.063229,-0.048211,0.025391,0.012351,-0.043004,-0.005959,-0.046934,-0.027998,-0.049839,0.033130,0.030718,-0.034264,0.009078,0.036681,-0.050335,0.040188,0.033453,0.005874,0.052677,-0.044965,0.026842,0.052744,0.019496,-0.054996};
  parameter real W240[0:249] = {0.018114,-0.050983,0.007389,0.050744,-0.014891,0.006041,-0.030932,0.016053,-0.039110,-0.065193,0.039125,0.055537,0.018744,-0.041173,-0.039247,-0.030106,-0.002441,0.050386,0.063533,0.011977,0.047843,-0.065962,-0.004773,-0.009521,-0.045521,-0.044234,0.058816,0.034152,0.003440,0.036336,-0.009893,-0.066559,0.034580,0.002508,0.065674,0.062933,-0.011997,0.052828,-0.021537,0.056216,0.001858,0.012993,-0.059389,0.047002,0.047331,-0.025650,-0.038587,-0.039417,-0.033491,-0.036464,0.042128,-0.052421,0.062191,0.060933,-0.032133,0.046727,0.006392,0.006853,-0.039517,-0.041281,0.017371,0.038161,0.049795,0.041917,0.057697,-0.049796,0.053762,-0.035815,0.050282,0.046916,0.066445,0.004771,0.058317,0.014886,-0.010699,0.031544,0.050870,-0.041648,-0.035645,0.017274,-0.045511,-0.052299,0.054927,-0.023126,-0.049087,0.043291,-0.025303,-0.061380,-0.013419,-0.039636,-0.016725,0.019414,-0.037040,0.023220,0.011474,-0.005654,-0.005148,-0.020486,-0.031306,-0.021743,0.000390,-0.033595,-0.013016,-0.041633,-0.041460,-0.022806,-0.018688,-0.057448,0.018412,0.007811,-0.010768,0.044462,0.024171,0.051102,0.042735,0.046279,-0.042574,0.038335,-0.023762,-0.062913,0.033575,0.033916,0.032396,-0.008270,0.058366,0.029067,-0.027502,0.041374,0.003672,0.027128,-0.000457,0.036662,-0.022682,-0.012736,-0.047629,-0.051321,0.034421,0.037631,-0.000517,0.024516,-0.002235,0.028915,-0.059182,0.034976,0.051069,0.008529,0.001868,-0.011720,0.057712,-0.037242,-0.047862,-0.025430,-0.038727,-0.037104,0.052574,0.055861,-0.035190,-0.025657,0.047264,0.026030,-0.049242,0.007045,0.034698,0.059938,-0.034481,0.018428,0.018034,-0.041589,-0.001691,0.030547,0.011926,-0.049477,-0.066371,0.029392,0.038136,0.023564,0.042173,-0.050025,-0.007940,-0.039586,-0.013146,-0.062866,-0.004547,0.021333,0.033499,0.053277,-0.009660,-0.050194,-0.034247,-0.000112,-0.056610,-0.060939,0.046077,-0.024160,0.069607,0.061210,0.050298,-0.018414,-0.011513,0.047296,-0.013335,0.059554,0.002497,-0.007522,-0.047401,0.006309,0.025100,-0.023675,0.059929,-0.048896,-0.009759,0.026510,-0.003558,0.063871,-0.057135,0.049350,-0.027368,0.037946,-0.059612,0.033487,0.014927,-0.010925,-0.044194,-0.023601,0.015260,0.002980,-0.034272,-0.029154,0.059913,0.008487,0.012572,-0.021155,0.028225,0.040850,0.061930,0.007300,-0.064182,0.065435,0.043666,-0.004155,-0.010459,-0.046593,-0.013057,0.059147,0.029168,0.044421,0.026306,0.042519,-0.038668,-0.002219};
  parameter real W241[0:249] = {0.016365,0.002198,-0.064297,-0.051071,-0.027986,0.010898,-0.020559,0.046393,0.000967,0.052485,0.049828,0.058489,-0.053833,-0.015657,-0.042277,-0.035862,0.000028,-0.037772,0.040751,-0.017640,0.008161,-0.006735,0.044301,0.029027,-0.051933,0.033440,0.007722,0.029643,0.057631,-0.030409,0.029027,0.064100,0.004476,0.043441,-0.059793,0.038139,0.004499,0.004815,-0.004447,-0.059315,0.025057,0.059733,-0.062269,-0.055264,-0.027756,0.058387,-0.055363,-0.035543,-0.040393,-0.003863,-0.057482,0.051027,-0.002985,0.013582,0.058060,-0.008629,0.005470,0.045215,0.055739,0.056078,0.003868,-0.022406,0.009500,0.010402,0.018209,0.052961,-0.043545,-0.026865,-0.025810,0.005720,0.049044,0.024181,-0.029135,-0.032506,0.004054,0.054881,0.040252,-0.003684,-0.061096,0.026008,-0.001253,0.020756,0.043314,-0.051060,-0.028972,-0.034058,0.001651,0.007928,-0.021401,-0.044555,-0.032637,-0.039696,0.045213,-0.009164,-0.022486,0.061109,-0.043889,0.024493,-0.037505,-0.052792,0.033171,0.015445,0.045418,0.044047,-0.029175,-0.041239,0.016276,0.011596,-0.058303,-0.044427,0.020652,-0.019539,0.003198,-0.018040,-0.010145,0.042387,0.015177,0.050029,-0.035147,-0.004395,-0.009820,0.004657,0.017562,0.012012,-0.004938,0.056351,-0.019822,0.026756,0.055507,-0.011253,0.057985,-0.022640,0.006329,-0.046183,0.040438,-0.062756,-0.036858,-0.056347,0.020342,0.006964,0.007367,-0.005807,0.060851,0.050629,-0.062913,-0.024130,0.025577,0.043433,-0.031707,-0.018310,0.044753,-0.038381,-0.056117,0.045761,-0.012032,-0.030232,-0.050415,0.058876,-0.034355,-0.046564,0.008120,0.061754,0.037955,-0.027949,0.036218,0.029637,0.011526,0.049434,-0.006844,-0.065009,-0.027394,0.038799,0.025768,0.034400,0.042226,-0.032772,0.054296,0.018927,0.019447,-0.025613,0.028772,0.031429,-0.045950,0.032270,0.028144,0.006644,-0.017087,0.013969,0.046449,-0.015418,-0.037220,0.035536,0.002858,-0.008987,0.033208,0.060943,0.057739,-0.037585,0.031531,0.058560,-0.025589,0.052916,0.027013,-0.041191,-0.057443,-0.034417,0.015189,-0.054470,0.024430,0.062332,0.046202,0.053851,-0.050156,-0.011697,-0.002133,-0.005450,-0.034912,0.040633,0.029879,-0.051734,-0.023004,-0.058250,-0.039482,0.042530,0.043732,-0.045993,0.056214,-0.040152,0.007464,-0.023770,-0.043142,0.060296,0.058239,-0.058226,0.031130,0.053365,-0.035933,0.027349,0.008091,0.057074,-0.049239,-0.008343,0.034392,0.043246,-0.006176,0.014765,-0.027049,-0.017743,0.047848,0.021716};
  parameter real W242[0:249] = {0.026703,0.045109,-0.045499,0.057264,-0.040629,-0.029804,0.051036,-0.017565,0.062172,-0.010432,-0.014535,0.007921,0.051781,0.056111,0.036743,-0.041345,-0.049132,-0.018774,0.033013,0.036284,0.015400,-0.001953,0.009250,-0.001358,-0.051327,0.016865,0.046852,0.034628,0.002414,-0.040852,0.061785,-0.048441,-0.007054,0.013064,0.039871,0.030810,-0.040179,-0.031710,-0.019122,-0.063361,0.053037,0.031769,0.051372,0.008875,0.023765,0.059951,0.057303,-0.041947,0.019317,-0.019502,-0.057155,-0.063218,-0.063946,-0.040357,0.031556,0.021720,-0.042179,-0.060973,-0.031406,-0.028698,-0.042914,-0.009898,0.063195,0.014007,0.023187,-0.036485,-0.006864,-0.049611,0.043238,-0.016053,-0.014170,-0.009752,0.004722,0.003516,0.022606,-0.005869,0.040609,0.062190,0.048277,-0.010624,-0.058378,-0.017117,0.060197,0.054319,-0.034844,0.015755,-0.044707,-0.001605,0.051422,0.018430,0.047082,-0.025062,-0.030566,0.006974,0.048206,-0.031381,-0.047408,0.054516,0.030407,-0.055289,0.023485,0.038892,0.025411,0.031704,-0.029812,-0.032391,-0.023723,0.038120,-0.033870,0.049800,-0.006866,0.032674,0.034475,0.020766,0.040563,-0.023347,-0.015834,0.061455,0.034887,-0.002213,-0.013733,-0.002164,-0.010300,-0.061901,-0.004229,-0.051275,-0.062078,0.021965,0.002505,-0.006515,0.046356,-0.010951,0.033530,0.023395,-0.036243,0.042978,0.026478,0.034906,-0.055664,0.057738,0.044662,-0.004458,-0.055008,-0.056542,0.051024,0.047513,0.020917,0.039617,-0.014409,-0.011551,-0.049841,0.016057,-0.012960,-0.027120,0.010787,0.048890,0.030095,-0.012676,-0.025961,0.031420,0.025393,0.013144,-0.013433,0.002355,0.014603,-0.057817,-0.054194,-0.013031,-0.030195,-0.010607,-0.007211,0.023369,0.022258,-0.042485,-0.018112,0.001629,0.057986,-0.053692,-0.060281,0.021387,0.027130,0.037721,-0.049241,-0.064024,-0.047522,-0.019788,-0.056370,0.034862,0.040819,-0.050977,0.041118,0.040139,-0.007883,-0.028369,0.055967,0.032115,0.052226,0.035825,-0.042677,0.007492,0.005081,0.053799,-0.066196,-0.043774,-0.044718,0.015317,-0.009340,0.041482,-0.036955,0.044351,0.002984,0.034920,-0.011529,-0.004447,0.019723,0.006205,-0.007247,0.054131,-0.061931,0.049495,0.023346,0.045893,0.016340,-0.052027,-0.043405,0.045380,0.022360,-0.031379,0.004312,0.000256,0.017260,0.029922,-0.014599,-0.021468,-0.026774,-0.017678,0.025554,0.000643,-0.030232,0.042191,0.057044,0.017572,0.033509,-0.063526,-0.018828,0.017762,0.003982,0.052970,0.056741,-0.033038};
  parameter real W243[0:249] = {-0.001109,0.041318,-0.046692,0.012382,0.027317,0.025872,0.049283,-0.033239,0.058001,-0.016121,0.026144,-0.029912,-0.005992,0.059859,-0.055027,-0.016276,-0.027635,0.052571,0.002752,-0.056876,0.000757,0.020771,-0.010394,-0.001927,-0.048384,-0.022120,0.038344,0.059610,-0.017724,0.033589,0.045487,-0.034833,-0.037305,0.057130,-0.048479,0.030286,-0.016312,-0.045488,-0.045493,0.040655,0.044207,-0.017345,-0.024534,-0.059914,-0.053919,0.058379,0.032739,-0.003004,-0.053202,0.003750,-0.008226,-0.059256,0.051925,-0.028603,-0.024819,-0.038180,0.002872,-0.000738,0.028731,0.028629,-0.048692,-0.037931,-0.014460,-0.002637,-0.057913,-0.030061,-0.005922,-0.033001,-0.043347,-0.034746,-0.058343,0.050489,-0.020904,0.041830,0.039560,0.005108,0.046624,0.063123,0.000241,-0.049279,-0.054339,-0.019673,0.021432,0.017904,-0.003582,-0.033658,-0.021761,0.054928,0.018228,0.044146,0.044433,0.042573,-0.054913,-0.043018,-0.057151,-0.064356,-0.043309,0.019418,0.046477,0.000313,-0.037128,-0.061507,0.059913,-0.048731,-0.048248,-0.000195,-0.047346,-0.043468,0.015608,0.004424,-0.047275,0.057775,0.041474,0.055355,-0.055625,0.054558,0.049161,-0.053327,-0.003422,-0.000141,-0.059782,-0.024296,-0.035397,-0.041898,0.043937,-0.027379,0.041264,-0.041977,-0.012108,-0.003544,-0.025492,-0.050540,0.001093,-0.000007,-0.057848,-0.023955,0.032599,0.025440,-0.022937,0.030008,-0.022990,0.045747,-0.036483,-0.024270,0.040707,0.024704,-0.005924,-0.018267,-0.033779,-0.009033,0.025545,-0.021429,0.029901,-0.013557,-0.044515,-0.017362,0.018019,0.001206,-0.049756,0.007693,-0.023645,0.001603,0.062581,0.013794,-0.004492,0.044433,-0.022834,0.023650,0.056727,-0.052522,0.008810,0.021686,0.020520,-0.020759,-0.034517,-0.058725,-0.001873,-0.012650,-0.051464,-0.041353,-0.033914,0.025636,0.007054,0.060071,-0.000325,-0.054169,-0.039858,0.051291,0.043169,0.044028,-0.005431,0.042552,0.054880,-0.043340,-0.059822,-0.055000,0.023058,-0.044814,0.052979,-0.051612,-0.057535,-0.024398,0.014332,0.042132,0.058038,0.037445,0.017593,-0.045422,0.037275,-0.054099,0.059122,-0.030377,0.053712,-0.008792,0.046979,-0.036222,-0.052154,0.000578,-0.042179,0.009798,-0.001204,0.015565,0.034810,0.043203,-0.017263,-0.006388,-0.047361,0.034179,0.036498,0.020297,0.003298,0.050220,0.045462,0.022149,0.023171,-0.052530,0.041135,-0.030748,-0.023067,-0.015152,0.040385,0.003856,0.016233,-0.022213,0.041280,-0.048616,0.055587,-0.031513,0.040400,-0.028662};
  parameter real W244[0:249] = {0.053062,0.021792,-0.028856,-0.005084,-0.003719,0.022347,0.026889,-0.061486,0.039779,0.042050,0.002736,0.058654,0.068236,-0.023354,-0.001030,0.012426,-0.047152,0.031683,0.018481,-0.053374,-0.030804,-0.010833,-0.015558,-0.026119,0.048364,0.037897,-0.058498,-0.033231,-0.046681,-0.045437,0.052755,-0.005693,-0.001709,0.025940,0.005034,0.027960,0.040228,0.021275,-0.029459,0.017587,0.040400,0.060669,-0.017502,0.005736,0.041226,-0.035935,0.061566,-0.058803,0.010615,-0.060184,-0.011774,0.046208,0.051685,0.000831,0.012154,-0.012497,0.023702,-0.003541,-0.049016,-0.021573,0.028035,-0.027670,-0.003458,-0.062249,-0.057617,0.059824,0.021966,0.041422,0.022476,-0.022749,-0.046736,-0.033030,-0.047479,0.005860,-0.045221,0.052439,-0.019713,0.005660,-0.012395,0.040355,-0.042322,0.029338,0.032620,-0.037652,-0.016210,-0.006950,-0.058922,0.013234,0.014051,-0.051415,-0.036023,0.059848,0.004259,-0.017133,0.031681,-0.063407,0.018044,0.003627,-0.018385,-0.050668,0.013545,0.000010,0.053571,-0.057129,0.006998,0.053645,-0.028109,-0.026393,-0.015646,-0.007230,-0.024304,0.050237,-0.048620,-0.023476,0.031170,0.054620,0.047786,-0.031247,-0.047237,0.029268,0.007001,-0.037076,-0.005274,0.000510,0.063193,-0.054062,-0.022367,0.020954,-0.034909,0.044360,0.040396,-0.015647,-0.057032,0.015459,-0.020214,-0.029264,0.037552,0.047259,0.033395,-0.024066,-0.030546,-0.049987,0.031631,-0.032431,0.005428,-0.042564,0.016019,-0.007479,-0.020294,0.054421,0.000187,0.055421,-0.022695,-0.000872,-0.027402,-0.051093,0.032713,-0.048662,-0.069363,-0.063146,-0.035534,0.031315,0.004051,0.032021,0.003976,0.064452,0.010326,0.028025,0.057537,-0.030668,0.034552,0.012932,0.054248,-0.005753,-0.022696,0.051013,-0.052376,-0.020550,0.047288,0.039895,0.026291,0.052505,-0.044643,0.014096,0.026349,-0.043951,0.020793,0.056167,-0.015668,0.013557,-0.035453,-0.014153,0.056201,-0.003838,0.000620,0.028556,0.031882,-0.025282,0.006699,-0.024638,-0.054348,0.049327,-0.002735,-0.057590,0.043371,-0.030038,-0.001234,-0.036269,0.006253,-0.008564,0.043397,0.013123,0.010160,-0.059969,0.002666,-0.033015,-0.000469,-0.026363,-0.037204,-0.031884,-0.048240,-0.034008,0.059690,0.030663,-0.048316,-0.041618,0.007692,0.001442,0.006038,-0.038820,0.023532,0.057328,-0.007123,-0.027508,0.041610,-0.044308,0.040264,-0.049809,0.063736,0.003337,0.020270,0.007253,0.030360,0.010298,-0.033584,0.050051,0.011406,-0.011867,-0.060182,-0.050656};
  parameter real W245[0:249] = {-0.051979,-0.006208,0.010390,-0.020463,0.031210,-0.005476,-0.021037,-0.031944,-0.010053,0.011925,0.056192,-0.040977,0.005784,0.011310,0.047141,0.024212,0.056627,0.034577,0.035005,-0.035509,-0.062581,-0.064492,-0.038957,-0.036983,0.059398,-0.009528,-0.047930,-0.051491,-0.038694,-0.012621,-0.046455,-0.033038,0.002661,0.060377,0.060640,-0.031322,0.015152,0.019422,-0.023845,0.058636,0.014240,0.043588,0.032965,0.050023,0.020826,0.015058,0.013256,-0.009585,-0.005099,-0.041264,-0.022116,0.009580,-0.031047,-0.001458,-0.010899,0.014702,-0.035784,-0.063463,0.061202,0.035143,0.032553,-0.024122,0.025664,0.028631,0.061051,-0.042283,-0.016993,-0.038730,-0.049940,-0.051557,0.030944,-0.055983,0.031316,-0.058995,0.049083,-0.036409,0.061392,0.018462,0.004232,0.048957,0.039633,0.030696,-0.016280,-0.038269,-0.014215,-0.039506,-0.058717,-0.009785,0.031865,-0.007156,-0.059176,-0.028980,-0.005800,-0.052529,-0.010276,0.028439,0.024494,-0.060635,0.025826,0.055432,-0.041693,-0.032819,-0.058908,0.007152,-0.023402,-0.029152,-0.037965,-0.053272,-0.044090,-0.037858,0.054771,0.035593,-0.061188,0.004624,-0.062816,-0.024909,-0.014069,-0.055891,-0.009580,0.036279,0.048135,0.035590,-0.050625,-0.024045,0.015918,-0.044572,0.020247,-0.057314,0.051319,-0.057488,0.030282,-0.045788,-0.046629,-0.013163,0.028331,0.022841,-0.006891,-0.001969,0.014860,0.034343,0.038368,-0.044302,-0.006330,-0.041234,0.020096,0.011610,0.024139,0.042369,-0.035247,-0.051263,0.033406,0.026203,-0.021320,-0.054809,0.054633,-0.055612,-0.050353,-0.048551,0.050081,-0.025261,0.021121,-0.039988,0.028499,0.046828,0.028081,0.005306,-0.009772,0.021350,0.001432,0.038427,-0.001542,-0.010508,-0.038496,-0.012202,0.005511,-0.009806,-0.046315,-0.033308,-0.045338,0.010039,0.003518,0.027474,-0.000819,-0.047765,-0.031191,0.037306,0.054365,0.032291,-0.047572,0.045122,0.002948,-0.053919,-0.028308,-0.002213,0.009593,-0.048982,0.004404,0.053730,0.063191,-0.046965,0.064345,-0.032605,0.037004,-0.025981,-0.041913,-0.009607,-0.051101,0.025356,0.011148,0.024506,0.033009,-0.041396,0.045330,-0.032264,0.009725,-0.007616,-0.041577,0.040600,-0.011535,0.062348,-0.051403,-0.044058,-0.061246,-0.049969,0.051789,0.017044,0.028551,0.058055,-0.051957,0.045802,0.013981,-0.011225,0.039438,-0.050713,-0.016733,-0.034290,-0.050578,0.063115,0.001479,0.019550,-0.017633,0.023826,0.052373,0.053402,0.004241,-0.063333,-0.035097,0.058059,0.038274,-0.063417};
  parameter real W246[0:249] = {0.053851,-0.000274,0.009910,-0.012179,0.058715,0.050233,-0.037439,0.057696,0.054669,0.033013,0.049393,-0.034731,0.005938,-0.005387,0.057028,-0.043814,0.003010,-0.013627,-0.040393,0.004513,-0.035726,0.040537,-0.008644,0.020934,-0.021214,-0.017328,-0.043572,-0.031716,0.020479,0.017704,-0.054875,-0.036093,0.015480,-0.022732,-0.017051,0.049710,-0.010251,-0.055471,0.050528,-0.038490,0.013917,-0.044969,-0.058417,-0.030797,-0.022311,-0.007379,0.007492,-0.005324,0.058239,0.003188,0.022210,0.055825,0.014940,-0.052568,0.002031,0.017778,0.045584,0.059983,-0.025377,-0.011012,-0.032532,-0.026723,-0.039933,0.015649,-0.041587,-0.021648,-0.038694,-0.048246,0.025225,-0.033658,-0.028413,-0.034230,0.005838,0.038228,-0.085181,0.005058,-0.051208,0.040790,-0.039305,-0.012449,-0.016192,-0.035853,0.032768,0.039651,0.042985,0.021991,-0.052707,0.030653,-0.055392,-0.047137,-0.033599,-0.007771,-0.056198,0.004215,-0.053826,0.003690,-0.000752,-0.001990,-0.051259,0.016912,0.036346,0.004168,0.034836,-0.008824,-0.061815,0.001651,-0.061530,0.017119,-0.057019,0.049000,0.039084,-0.005936,-0.054137,-0.032472,-0.046206,-0.040439,-0.025685,0.024213,-0.005912,0.046963,0.044757,0.055278,-0.039149,-0.013658,-0.039023,-0.013571,-0.008648,0.010005,0.011172,0.014596,0.020781,-0.046308,0.035188,0.053849,-0.018254,0.003435,0.015843,-0.041995,-0.049810,-0.037884,-0.024316,-0.047497,-0.013515,0.013140,0.064349,0.056441,0.040727,-0.012075,0.045619,-0.028448,-0.040231,0.024612,0.062825,-0.039076,-0.030145,0.000179,0.033763,0.052351,-0.008572,0.032341,0.060236,0.009826,0.030800,0.043246,0.047210,0.027853,-0.040341,-0.008970,0.023980,0.014740,0.037592,-0.043086,0.021765,-0.053599,-0.006774,0.038122,-0.000705,-0.006724,0.068544,0.033717,-0.050524,0.030326,0.043198,0.019917,-0.031464,-0.046790,-0.047788,0.055196,-0.039629,0.060636,-0.007702,0.012768,-0.020429,0.003516,0.040039,0.059222,-0.019805,-0.016991,-0.012111,-0.027193,-0.038577,-0.030439,-0.025331,-0.022481,0.057672,0.033629,0.017056,-0.061002,-0.056858,0.009716,-0.055531,-0.042054,-0.004704,0.052370,-0.016617,0.019601,-0.040729,-0.025246,0.059521,0.052090,-0.043566,0.020083,-0.029705,0.014737,-0.033500,0.041340,0.054359,0.022694,-0.027160,-0.055974,-0.062052,-0.044386,0.036103,0.025945,-0.007214,0.047717,0.023441,-0.038842,-0.049100,-0.019905,-0.065214,0.046306,-0.038166,-0.042678,0.014439,-0.022723,-0.039683,-0.052276,0.004037,0.015218};
  parameter real W247[0:249] = {-0.038797,0.032231,-0.005938,0.000507,0.045338,-0.028118,0.039433,0.058202,-0.043621,-0.040164,-0.042904,0.026552,0.046132,-0.023452,-0.039738,-0.004594,0.024693,0.030996,-0.042281,0.023701,-0.014801,-0.039425,0.036176,0.012711,0.045275,-0.012721,-0.007104,0.021800,-0.047481,0.027154,0.019736,0.055875,0.020092,-0.003032,-0.000998,0.012978,-0.043614,0.032256,0.057174,-0.025347,-0.027942,-0.023217,0.058234,-0.002398,-0.015652,-0.048029,-0.021481,-0.055256,0.039368,0.022311,-0.038575,0.026083,0.038452,0.061424,0.016425,0.053928,0.003065,-0.045677,0.050580,-0.019851,-0.009965,-0.031951,0.041629,0.016512,-0.064384,-0.059857,-0.013717,0.048390,-0.021869,-0.021107,0.045779,-0.065134,-0.051499,-0.034243,0.051564,0.036095,-0.016873,0.011369,-0.019672,-0.018967,-0.027224,0.013375,0.018598,0.016938,-0.029555,0.029893,0.018532,0.008680,-0.005685,0.042556,-0.030161,-0.031990,0.037921,-0.050895,-0.003736,-0.024243,0.034377,0.013326,0.006133,0.040834,0.023445,-0.034464,0.028172,-0.036284,0.016885,0.021787,-0.007369,0.045276,-0.033619,0.040060,0.049232,0.063001,0.015233,0.054139,0.050847,0.010785,0.045790,-0.000510,-0.061748,-0.012808,0.062930,0.029981,0.002658,0.057380,0.058210,0.041723,0.060813,-0.021163,0.018625,0.014141,0.010394,-0.044691,-0.063328,-0.034936,0.017173,-0.049953,0.068296,0.053143,-0.027490,-0.041525,-0.040204,0.017221,0.039365,-0.032229,-0.042564,0.023734,-0.032161,0.038696,0.002919,0.034363,-0.023590,-0.027758,0.031305,0.013339,-0.013133,-0.035051,0.053000,-0.018152,0.057184,-0.011474,0.001472,0.019503,0.062602,-0.058609,-0.041693,0.052032,0.046258,0.060488,0.012886,-0.032495,0.051947,0.031682,-0.042450,-0.047835,0.035090,-0.030596,-0.044593,0.053817,0.044183,0.001312,0.028166,-0.001261,-0.051557,0.040537,-0.004869,0.048162,-0.052861,0.000193,0.014960,0.038740,0.017563,0.010669,-0.061808,0.041778,0.059850,-0.004868,-0.059508,-0.018178,0.050316,0.035284,0.023069,-0.028444,0.035430,-0.027772,-0.052700,0.037774,0.025925,0.067806,0.061649,0.040837,-0.012686,0.042962,-0.062540,-0.004252,0.026171,-0.038864,-0.002183,-0.048497,0.047922,-0.009797,-0.026145,0.009992,0.030243,-0.031796,-0.024812,0.033880,-0.001053,-0.016674,-0.039940,0.061093,0.030530,-0.032383,0.054891,0.055385,0.008817,-0.038937,0.038240,-0.049602,0.034440,0.029037,0.032762,0.004032,-0.047572,-0.001997,0.024775,-0.008526,0.047412,0.018941,0.037250,-0.048955};
  parameter real W248[0:249] = {-0.059015,0.050690,-0.026370,0.034825,-0.019505,-0.048428,-0.018801,0.047140,0.015801,0.057758,-0.009817,0.053965,-0.023462,-0.061926,0.001592,-0.045797,0.014386,0.036235,-0.038928,0.005822,0.046345,0.050967,-0.043370,-0.062765,0.020102,-0.006363,0.002491,0.055769,0.055041,-0.039073,-0.043206,-0.062968,0.055430,0.041121,-0.033205,0.019231,0.013303,0.031139,-0.037060,0.017898,0.031802,0.040291,-0.020895,-0.050313,-0.045614,0.011848,0.039614,-0.054285,0.035017,0.000177,-0.039839,-0.056829,-0.036714,0.031480,0.006160,0.016610,0.005404,-0.016091,-0.023171,-0.009959,-0.041140,-0.036095,-0.025089,0.006165,0.062193,0.042836,-0.023700,0.059372,-0.010586,0.013004,0.041945,-0.010512,-0.039122,0.025302,-0.021698,0.016318,0.026219,-0.058499,-0.043942,0.012840,-0.006655,-0.008062,0.055535,0.045574,0.042546,-0.021606,0.055940,-0.050214,-0.060857,-0.004190,0.026462,-0.015659,-0.015614,0.036059,-0.003447,0.001185,-0.035882,-0.046574,-0.007430,0.003220,-0.050471,-0.032286,0.024261,0.031218,0.045348,-0.032566,-0.059312,0.059044,-0.032462,-0.031864,0.058036,0.053865,-0.055299,0.023263,0.027678,0.056606,-0.019170,0.003188,0.038274,0.050504,0.052212,-0.061869,-0.014922,0.000311,0.061662,-0.023274,0.061015,0.030249,0.029331,0.036200,-0.057291,0.061329,0.036621,-0.061087,-0.008946,-0.047340,-0.011516,-0.023780,0.046679,-0.035061,-0.003674,0.032755,0.037026,0.001434,0.008395,-0.026823,-0.029443,0.048654,-0.041001,0.065594,0.020108,-0.032546,0.037653,0.004388,0.013571,0.020325,0.026244,-0.052724,0.011834,0.055115,-0.014852,0.022454,0.044252,0.022955,-0.002073,-0.005628,0.041362,0.044729,-0.062144,-0.061973,-0.017333,0.056253,0.058199,-0.009306,0.015144,0.047192,0.021067,0.029506,0.030452,-0.022134,-0.001825,0.005479,-0.000323,0.042427,-0.016841,0.022429,0.015393,-0.033587,0.024683,-0.006184,-0.000985,0.026296,0.013432,0.059630,-0.037715,0.006491,-0.057531,0.024531,-0.056740,0.040958,0.011097,-0.019966,-0.054898,0.035287,-0.031606,-0.035791,0.044673,-0.027404,0.032068,0.059595,0.025580,-0.052994,-0.048853,-0.031776,0.052908,-0.025756,-0.051257,-0.058373,0.038903,0.043326,-0.006449,-0.015405,0.045067,-0.059160,0.023822,-0.032896,-0.033411,0.018726,0.046044,0.026949,-0.041685,0.051414,0.004624,-0.002439,0.042330,0.023094,0.041385,-0.037065,-0.015774,0.045585,0.047689,-0.057055,0.019090,-0.027880,0.026986,0.007858,0.022791,-0.039000,0.015573,0.055862};
  parameter real W249[0:249] = {0.043283,0.044182,-0.054665,0.029470,0.038036,-0.005278,-0.041801,0.042821,0.053281,0.015674,-0.004462,-0.042850,-0.063412,0.032514,-0.027127,-0.002290,-0.020300,0.048904,-0.053065,0.019013,0.009295,0.005601,0.035726,0.036137,0.054542,0.033978,-0.040605,0.003843,0.022514,0.039076,-0.032847,-0.064898,-0.038518,0.007346,0.026239,-0.048741,0.007668,-0.039238,-0.008609,-0.015406,-0.014625,0.040214,0.019963,-0.058166,0.044373,-0.032498,-0.004454,-0.027609,-0.019072,0.015409,0.011768,0.040060,0.038622,-0.015814,0.030524,-0.029419,-0.012230,0.065841,-0.057572,0.035474,0.051035,-0.041492,0.022896,0.059380,-0.000315,0.002033,-0.002644,-0.014075,0.038626,0.014527,-0.042736,0.046546,0.024040,-0.008365,-0.052927,-0.052007,-0.001979,-0.057536,0.044796,0.035831,0.047050,0.006177,0.050270,-0.039212,0.039304,0.049764,-0.014764,0.056742,-0.039535,0.044614,-0.007332,-0.025950,-0.003627,0.009463,-0.034873,-0.021579,-0.025256,-0.031673,0.000598,-0.058498,-0.032771,-0.003005,-0.018847,0.053343,-0.009979,0.000157,-0.043663,0.023686,0.049466,0.036956,0.021271,0.055476,-0.007192,-0.019491,0.034047,0.044145,0.042746,-0.026739,-0.028842,-0.031100,0.027483,-0.051377,0.043263,-0.005619,-0.033069,-0.017810,-0.028264,-0.016166,-0.023751,0.057782,-0.048059,0.024131,-0.048034,-0.058020,-0.021463,0.039662,0.038993,-0.032690,-0.071474,0.011515,0.015768,0.049369,0.000911,-0.031416,-0.052705,-0.021532,0.030713,-0.016336,-0.035587,-0.028383,-0.015909,0.023498,-0.023419,-0.021525,0.000802,-0.025695,0.062770,0.009142,-0.055787,-0.062427,0.055263,0.046070,-0.011364,-0.039032,0.039043,-0.050415,0.007968,0.030993,-0.056401,-0.037197,0.010419,0.012097,0.045663,-0.040212,0.051508,-0.041729,0.048068,-0.034766,-0.064770,-0.016605,0.030619,0.032039,-0.014348,-0.010452,-0.065075,-0.030415,-0.050038,0.003496,-0.057029,0.009127,0.007282,0.038363,0.003403,-0.032405,-0.039832,-0.037863,0.025552,-0.061726,0.019148,-0.006190,-0.063131,-0.020473,0.058966,-0.063668,-0.026739,0.024004,-0.048158,-0.059905,0.024852,-0.011145,-0.019920,-0.020206,0.007314,-0.030937,0.010439,-0.024949,-0.010097,-0.037921,0.057007,0.010409,0.039775,0.028305,0.051963,-0.047764,-0.041985,0.014113,0.022763,0.024022,0.016270,0.028289,-0.011349,-0.000429,-0.050579,0.008486,-0.058022,0.042791,0.061971,-0.048696,0.052533,-0.021982,0.059789,-0.029599,-0.001650,-0.062195,0.012186,0.064067,0.041232,-0.040865,0.060775,0.039489};
  parameter real W250[0:249] = {0.013056,-0.016939,0.025546,0.030749,-0.051703,-0.044138,0.026280,0.002982,0.004634,0.045334,-0.037806,0.007724,-0.046730,0.026156,-0.023911,0.030549,-0.001234,0.048441,0.021093,-0.039315,-0.010267,0.045732,-0.028615,0.045707,-0.035058,-0.052779,-0.014011,0.017966,0.000187,0.017096,0.013433,0.015960,-0.057553,-0.028220,-0.024741,-0.027840,-0.002815,-0.056269,0.005582,0.022258,0.038593,-0.023653,-0.060799,-0.043346,0.047156,-0.053069,-0.000002,-0.019921,-0.010984,0.049641,0.002050,0.062254,0.039232,0.050758,0.006040,0.009736,-0.012907,-0.008589,-0.008948,-0.038427,0.036279,0.027105,0.010153,0.031849,-0.003362,0.049512,-0.017115,0.044117,0.044451,-0.013326,0.023574,-0.004885,-0.002332,0.004989,-0.043662,0.033880,0.002547,-0.020763,-0.061932,-0.006403,0.028367,0.002221,-0.031758,0.042853,-0.003435,0.047045,0.040845,-0.006547,0.009985,-0.041860,0.019358,-0.015822,0.050134,0.029336,0.002193,-0.047089,-0.034212,0.036981,0.003491,-0.024464,-0.043761,0.028582,0.015547,0.053594,0.042855,0.020201,-0.046062,-0.028470,-0.006471,-0.024438,-0.033407,0.024548,-0.029386,-0.040797,-0.043014,-0.024129,-0.052816,-0.032043,-0.014039,0.018000,-0.053385,-0.017039,-0.009010,0.028023,0.013990,-0.060841,-0.037858,0.045557,-0.039394,-0.027558,-0.005052,-0.040963,-0.022613,0.002147,-0.031430,0.038614,-0.017809,0.005531,0.003562,-0.058757,-0.037127,-0.029140,0.011734,-0.062443,0.030737,0.002928,-0.014212,0.000530,-0.032610,-0.043326,0.023559,-0.004277,-0.049378,0.023324,0.055621,0.009691,-0.037575,-0.043319,-0.004318,0.031356,-0.050133,-0.054761,0.038238,0.005726,-0.002405,-0.042900,-0.006040,0.020748,-0.063700,0.002113,0.023829,0.048575,-0.022493,-0.025257,0.018155,-0.040016,0.038377,-0.055886,0.012168,0.054171,0.045623,0.032955,0.059532,-0.041293,0.012877,0.022500,-0.040052,0.008668,0.036701,-0.050938,0.055578,0.013190,0.016263,-0.036044,0.056088,0.006146,0.012555,-0.009833,0.042635,-0.032794,-0.005892,0.005235,-0.003028,0.051662,-0.055652,0.009895,-0.008334,-0.043412,0.000217,0.000245,-0.020960,-0.021177,0.046284,-0.037222,0.055041,-0.046159,-0.050370,0.030540,0.009850,0.056953,-0.017430,0.034658,-0.016204,-0.034401,0.036196,0.058172,0.045771,-0.040079,0.018150,0.064849,-0.002111,-0.044491,0.026027,0.004423,-0.063624,0.058553,-0.061021,-0.003187,-0.035440,0.047297,-0.014159,0.035634,-0.012792,0.019742,0.048738,0.051370,0.028825,-0.062711,-0.054499,-0.000544};
  parameter real W251[0:249] = {0.058050,0.014715,-0.051642,-0.046730,0.027847,0.032819,-0.038156,-0.007902,-0.049752,0.038064,-0.051028,0.040814,0.000433,-0.015119,0.030508,-0.035561,-0.020002,-0.020118,0.032023,-0.043940,0.030776,-0.019065,0.039460,0.025970,-0.051103,0.044068,0.054770,0.017722,0.007105,0.060984,0.047240,-0.054522,-0.038463,-0.024421,-0.045961,0.042421,-0.046204,0.043431,0.006629,0.001233,0.032862,-0.036390,-0.028332,0.003810,0.019607,0.032465,0.048892,-0.042894,0.050554,0.037330,-0.002463,0.028067,0.029284,0.025395,-0.051095,-0.042969,-0.031692,-0.057294,0.046564,0.000661,-0.017084,0.052972,0.051328,0.035670,-0.030949,0.026661,-0.021479,-0.016096,-0.061314,-0.002117,0.029369,-0.010492,0.008516,0.046573,0.027167,-0.041534,0.043341,-0.012659,-0.061139,0.030909,-0.007029,-0.019974,0.022176,-0.046291,0.031592,0.007281,-0.006552,0.061035,0.033051,-0.046637,0.022804,0.041665,0.014647,-0.040914,0.013030,0.057703,0.006888,-0.028339,-0.053970,0.013630,0.058435,0.048158,-0.005782,0.000829,0.040386,0.021841,-0.050312,0.022214,-0.016618,-0.052507,-0.029314,-0.044548,-0.015829,-0.062434,0.030865,0.000177,-0.031179,-0.022832,-0.045775,0.013997,0.048103,-0.030376,-0.036098,-0.043927,0.009822,-0.047252,-0.056150,0.037517,0.017387,-0.029348,0.042179,-0.044534,0.051270,-0.031051,0.031331,-0.060428,-0.013236,0.037692,0.024436,0.036978,-0.059454,0.000703,0.032417,-0.022409,-0.000172,-0.034274,-0.021237,-0.001391,-0.057503,0.023548,-0.052275,0.030842,-0.026028,0.007630,0.041197,-0.019106,0.003251,-0.051024,-0.048624,0.029079,0.025310,0.024639,-0.012412,-0.028936,0.054265,-0.047597,-0.030511,0.003135,0.008510,-0.044261,-0.012615,0.041965,-0.011171,-0.000013,0.036411,0.042317,0.023006,-0.036185,0.036433,-0.053423,0.010644,-0.033977,-0.010508,-0.061897,0.021645,0.053116,-0.013207,-0.033200,-0.009571,0.002128,-0.041781,-0.043965,0.027613,0.005478,0.020296,0.000646,0.010706,-0.037653,-0.027533,-0.017782,-0.023092,0.026872,-0.050192,-0.012338,0.030134,-0.042175,0.030882,0.029979,0.025775,0.017216,0.015192,0.052026,-0.021875,-0.058712,0.008906,-0.000824,-0.043870,-0.016592,-0.005853,0.059348,0.004681,0.057579,0.028053,-0.053431,-0.058913,0.040022,-0.008077,0.062010,-0.019263,-0.036793,0.018751,-0.046159,-0.045822,-0.011548,-0.002181,0.027396,0.033702,-0.014365,-0.059302,-0.003187,-0.034420,-0.061849,-0.015713,-0.045609,-0.063146,0.037401,-0.040758,0.014755,-0.028348,0.047126};
  parameter real W252[0:249] = {0.039754,-0.043538,-0.041280,-0.051586,-0.036417,-0.016296,-0.032472,0.012883,-0.028497,-0.003939,-0.043360,0.008232,-0.000229,0.020555,0.050915,0.035406,0.007772,0.000554,0.055193,-0.061058,-0.006645,-0.028430,-0.025687,0.066788,-0.038487,0.033131,0.004847,0.014714,0.035783,0.055025,-0.042476,0.031938,0.058535,0.049128,-0.026066,-0.032169,0.040869,0.018729,0.016816,-0.034515,-0.019947,-0.026729,0.039862,0.003626,0.048852,0.004213,-0.067967,-0.041328,0.005958,0.008913,0.044824,0.040669,0.040541,-0.021305,0.015246,0.042729,-0.039531,0.020491,0.031646,-0.030035,-0.034234,-0.002324,-0.028648,0.033402,0.022596,-0.046064,-0.016908,-0.043074,0.026257,-0.061152,-0.000005,0.049731,0.009308,0.049020,0.083242,-0.042474,-0.066174,-0.037626,-0.024006,0.051646,0.055887,-0.056435,-0.061929,-0.040841,0.068510,-0.038750,-0.002554,0.009684,-0.026243,-0.024772,-0.034425,-0.048020,-0.048186,-0.001115,0.053709,0.042439,0.004801,0.013545,-0.003733,0.058212,-0.049079,0.043825,-0.053683,0.056268,0.051052,0.028071,0.028845,0.014265,-0.021299,0.010330,-0.030012,-0.053770,-0.047165,-0.008872,-0.011690,0.009833,0.048850,0.052173,0.006777,0.010845,0.035256,0.062572,-0.032493,0.029025,0.062289,-0.020671,-0.020950,0.058096,-0.009759,-0.033145,0.025654,-0.060267,-0.040495,0.041163,-0.004055,-0.056297,0.010593,0.006359,0.054450,0.041368,-0.050675,-0.042930,-0.000051,0.042450,-0.039891,-0.054624,-0.046001,0.034774,0.027289,0.012869,0.052174,0.008323,-0.046156,0.071798,-0.018093,0.020876,0.030231,0.009463,-0.046376,-0.012359,0.005355,-0.010228,0.012905,-0.059242,0.033183,-0.025343,0.013437,0.052334,0.055224,-0.009367,-0.024941,0.055971,0.045307,0.011260,0.063728,-0.009091,-0.052798,0.000819,0.051755,-0.053188,0.042497,0.018073,0.047209,0.031109,0.006995,-0.043797,0.064818,0.038301,0.024796,-0.014331,0.018927,-0.041593,0.014087,0.025052,0.001864,-0.031628,0.010430,-0.037686,-0.012179,0.000746,-0.033291,0.028181,0.060394,0.040067,0.005120,-0.005183,0.030934,-0.000635,0.031258,0.000888,0.020792,0.008664,-0.026344,-0.031526,-0.051188,-0.048519,-0.022802,-0.030991,0.050799,0.041449,0.023410,-0.013360,-0.015167,0.021837,0.036102,-0.048456,-0.044812,0.036967,0.012303,-0.031464,-0.023507,0.003289,-0.048836,-0.006942,0.044612,0.042260,0.054631,-0.051844,0.063358,0.000173,-0.032166,0.024651,-0.023497,-0.028570,-0.020482,0.021799,-0.000575,0.006144,-0.062018,0.035341};
  parameter real W253[0:249] = {-0.026424,-0.025211,-0.012061,0.020001,0.030209,0.030982,-0.058072,0.021712,-0.036384,0.047758,0.045959,0.033974,-0.050593,-0.019961,-0.013051,0.061043,-0.040907,0.039154,-0.043805,0.048431,-0.056733,-0.004638,0.045483,0.058360,0.031672,0.001338,-0.003084,-0.017679,0.013831,-0.009340,0.010350,-0.051902,0.045387,0.019047,-0.008944,-0.050847,-0.037558,-0.012137,-0.042395,0.003112,0.026458,-0.053466,0.040477,0.008941,0.030990,0.058700,0.061025,0.047107,0.050671,-0.060323,-0.029024,0.047961,-0.018994,0.015141,-0.056629,0.001369,-0.025314,-0.059226,0.032918,0.040544,-0.034781,-0.058848,0.010484,-0.028084,0.004537,-0.017625,-0.014483,0.013205,-0.049603,0.012486,0.048561,-0.039401,-0.014262,0.063570,-0.063821,-0.004884,-0.043053,-0.034567,0.014123,0.001280,-0.048305,-0.038266,0.050461,0.002958,0.004080,0.062988,-0.020037,-0.037257,-0.027176,0.028801,-0.038887,0.000319,-0.032499,0.008726,-0.013709,0.035570,0.037481,0.031251,0.007745,0.001230,-0.003463,0.012463,-0.007722,0.006659,0.057211,0.054620,-0.032594,-0.007530,-0.027975,0.014653,-0.060657,-0.011484,-0.039715,0.031861,0.001438,0.059692,-0.027963,0.050725,0.008069,0.020457,-0.027227,0.037298,0.020656,-0.004441,0.042838,-0.048857,0.013059,0.044675,-0.030752,0.031315,-0.050319,-0.002353,-0.020959,-0.042880,-0.002084,0.048229,-0.009586,0.050568,0.019875,-0.054381,0.039238,-0.046862,0.053192,-0.057149,0.055771,0.013121,0.015256,0.041914,-0.025124,0.011879,-0.028041,-0.064470,0.042069,-0.024513,-0.063504,-0.038164,0.039543,-0.042022,-0.052280,0.030162,0.032803,0.010713,0.052829,-0.022984,0.017704,-0.056916,0.032029,-0.041657,0.028633,0.059401,0.009362,-0.006844,0.026627,0.013339,0.062286,0.035178,-0.047944,-0.060830,0.020745,-0.038269,-0.002539,-0.033019,0.051683,0.050194,0.015338,0.023683,-0.019225,-0.058193,0.035599,-0.001645,0.052377,0.014766,0.033275,-0.054450,-0.058520,-0.022356,0.048137,0.033540,0.027446,0.022111,0.056444,0.043824,0.000081,0.011486,0.045684,0.026616,0.052493,0.039813,0.007415,0.056752,0.011391,0.012227,0.054327,-0.030282,-0.043836,0.036063,-0.037801,-0.042561,0.055901,0.046230,0.050922,0.045239,0.045007,-0.049079,0.017458,0.047578,0.058002,-0.005956,0.045990,0.021234,0.023390,0.040849,0.054843,0.042015,0.060276,0.005224,-0.057925,-0.026506,0.033579,-0.002048,-0.005159,0.061574,0.002828,-0.038237,0.043406,0.017421,-0.002545,0.018560,0.027594,-0.060830};
  parameter real W254[0:249] = {-0.046134,0.033932,0.005212,0.050769,-0.006009,0.008330,-0.052482,-0.041591,0.018263,-0.020292,0.003701,0.033679,0.002309,0.035273,0.000437,-0.014168,0.009019,-0.008641,0.001439,0.052976,0.041144,0.059810,-0.024455,-0.016013,-0.038689,-0.005509,-0.042635,-0.041278,0.008047,0.006532,0.063334,-0.016539,-0.035693,-0.005605,-0.031295,0.007197,0.043078,0.044615,-0.048689,-0.059244,-0.059966,0.058142,0.011845,0.002612,0.021773,0.028937,-0.058824,0.059445,-0.014383,0.056803,0.016374,-0.052652,0.020381,0.062621,0.007789,-0.049499,0.060634,0.020007,0.042902,-0.031972,0.010642,0.054717,0.033246,0.019476,-0.035338,-0.059210,-0.028485,-0.055415,0.045476,0.008257,0.006044,0.022022,0.050578,-0.049910,-0.040669,-0.018504,0.035996,0.030157,-0.033588,0.037153,0.010583,0.017793,-0.026705,-0.015353,-0.003584,0.037367,0.023663,0.010766,0.061500,-0.053741,0.056966,-0.048670,-0.023204,0.000764,-0.000949,-0.016825,-0.022172,0.006763,-0.041680,-0.059697,-0.004392,-0.046294,0.051200,0.016369,0.027264,-0.060242,-0.032111,-0.037257,0.059830,-0.039436,0.010648,-0.025515,0.058217,-0.033903,0.016878,-0.008477,-0.056012,-0.023878,-0.021223,0.048101,-0.035381,0.032267,-0.024546,-0.012062,0.025040,-0.045021,0.040551,0.008968,0.030302,-0.063158,-0.049357,-0.048333,-0.043326,0.018636,0.024621,0.058025,0.036723,0.044066,0.017607,-0.025029,0.008069,0.020973,-0.027105,-0.032548,0.060225,0.035313,0.051887,-0.044715,-0.025290,0.004540,-0.030345,-0.033101,-0.017066,-0.008658,-0.061761,-0.025293,-0.059233,0.020547,0.028926,-0.015313,0.033902,-0.021003,0.031181,0.046952,0.049806,0.030042,0.047601,0.050223,-0.004165,-0.030521,0.005255,-0.034747,0.055727,-0.024700,0.038282,-0.041242,-0.024712,0.016443,0.043578,-0.018488,-0.052838,0.010505,0.022209,0.058436,0.047092,0.062123,-0.051642,0.045604,-0.056441,0.050344,0.016013,0.015546,0.023142,0.032070,0.046166,-0.053805,0.048225,0.011625,0.036402,0.007693,0.001952,-0.002698,-0.020919,-0.018325,-0.011050,-0.058423,-0.016628,-0.022289,-0.012487,-0.043158,0.038545,-0.050653,0.015055,-0.060189,0.054747,0.028803,-0.007667,0.029943,-0.017938,-0.006144,-0.009449,0.023890,-0.023610,-0.055986,0.036147,-0.054430,0.058412,-0.009704,0.001726,0.019829,0.038704,-0.028098,0.015698,-0.025001,-0.007194,-0.039247,0.057394,0.029093,0.056163,0.031638,-0.016008,0.043989,-0.053440,-0.007016,-0.059311,0.037341,0.044275,0.002107,0.045084,0.021251};
  parameter real W255[0:249] = {-0.065779,-0.041070,0.010061,0.060502,0.042003,0.000530,-0.049926,0.059113,-0.066547,-0.022400,-0.036407,-0.008929,0.015639,-0.038163,-0.057612,-0.039203,0.052401,-0.051939,0.062760,0.019816,0.003680,-0.046424,-0.032887,-0.057472,0.039520,-0.018317,0.046122,0.036502,-0.026049,-0.038930,-0.006490,0.027198,0.025685,0.005030,0.013973,0.010975,-0.033813,-0.016148,-0.043350,-0.030227,-0.009902,0.032885,-0.008519,-0.060349,-0.020285,0.051730,-0.000249,-0.043079,-0.025401,0.002830,-0.031904,0.025474,0.016071,-0.010470,-0.060448,0.040052,-0.031336,-0.041078,-0.032622,0.028759,0.055140,-0.051949,-0.050981,0.021499,-0.000117,-0.035941,-0.062702,0.027257,0.025609,-0.026531,0.015636,0.007219,0.023424,0.045406,-0.052211,0.014697,0.032931,0.021149,-0.025792,0.048903,0.064101,0.054677,0.005229,0.059866,0.016132,-0.063027,0.017136,0.042905,-0.045609,0.036200,-0.000847,-0.002217,-0.062038,0.059260,-0.052225,-0.008539,-0.025130,0.053959,-0.038458,0.053689,0.016612,-0.045059,0.037428,0.003573,-0.003235,-0.054235,-0.026684,-0.022170,0.007185,-0.055036,-0.003018,0.044888,-0.054398,-0.022176,0.019708,0.051799,0.014803,0.054283,0.012221,-0.038373,0.007103,0.026822,0.048283,-0.018392,0.008673,-0.015864,0.007485,0.064883,0.058052,0.046146,-0.047517,0.022670,0.003286,0.038497,-0.035176,-0.035868,0.036453,-0.004762,-0.009101,0.039421,-0.022798,0.058391,-0.013570,-0.037854,0.047854,-0.062207,-0.019013,0.018004,0.015958,-0.017117,0.043622,-0.000406,-0.047228,0.022660,0.045715,-0.028665,0.058897,-0.042493,0.005575,0.003137,0.038622,0.060167,0.007491,-0.012262,0.019951,0.016041,0.011952,-0.046964,-0.058512,-0.020597,0.002463,0.023096,-0.011485,0.022247,-0.026708,0.008756,-0.046017,0.059131,-0.055074,0.041122,0.001428,-0.055398,0.022786,-0.009452,0.022180,-0.000816,0.049202,0.011135,0.049735,-0.049812,0.007997,-0.012687,-0.047282,-0.038313,0.053432,-0.022677,-0.044483,-0.018706,0.047322,-0.037701,0.037316,-0.056485,0.060660,-0.053613,-0.049300,0.007814,0.009510,0.020010,-0.060612,-0.007447,0.054488,-0.014636,-0.022017,0.058549,-0.045178,0.024932,-0.049264,-0.018834,-0.037807,0.043802,0.028139,-0.005651,0.043825,-0.029048,-0.010194,0.050334,0.040446,0.042888,0.007093,-0.039414,0.004610,0.049420,0.011112,0.015835,-0.014444,0.006406,-0.027078,0.044435,-0.029658,-0.011512,0.011272,0.035524,-0.047464,-0.036515,-0.006236,0.029606,0.017332,0.040390,-0.062912,0.044533};
  parameter real W256[0:249] = {0.048426,-0.058696,0.012986,0.041166,-0.010349,-0.011103,-0.015990,0.013660,-0.060861,0.041566,-0.036381,-0.038002,-0.034120,-0.040036,0.006916,-0.049710,0.052383,-0.021608,0.058401,0.051070,-0.044487,-0.008838,0.009620,-0.056471,0.060666,0.046098,0.058297,-0.054355,-0.037067,0.008187,0.049937,0.007829,-0.067074,0.046831,-0.006251,0.013051,0.040454,-0.016492,0.043770,-0.053830,0.035528,-0.024601,-0.010391,-0.027257,-0.048748,0.001674,0.064503,0.003952,-0.060848,-0.001907,0.035356,-0.030816,0.029281,-0.014682,-0.005104,0.010006,-0.023381,0.042956,-0.057789,0.061623,-0.040662,0.014379,0.018195,0.040961,-0.018896,0.044987,0.039626,-0.022309,0.014875,-0.009618,-0.029978,-0.055198,0.018769,-0.025879,-0.029534,0.013381,-0.046024,0.059761,-0.006627,0.058168,0.019404,0.024488,0.030929,0.062980,0.036175,-0.022304,-0.066548,0.023565,-0.030105,0.044265,-0.048386,0.013325,0.056263,0.041186,-0.040430,0.044684,0.056864,-0.031013,-0.034279,-0.029305,-0.022893,-0.060737,-0.018345,-0.049185,0.006986,-0.041550,-0.058835,0.027862,-0.043027,-0.033313,-0.007476,0.052643,-0.062896,0.055639,0.045690,-0.017931,0.004336,-0.003232,0.021971,-0.002948,0.009857,-0.022930,0.066279,0.043056,-0.039609,-0.020641,0.043871,0.046588,-0.050220,0.037177,0.004973,0.017524,0.039124,0.017655,0.018945,0.045671,0.037324,-0.033632,0.044847,0.014666,0.036254,-0.022936,-0.041813,-0.010699,-0.023646,-0.017875,-0.042144,-0.030041,0.052955,-0.060157,-0.013526,0.022773,-0.044800,0.027253,-0.036042,-0.017512,-0.003448,0.013440,0.030892,-0.030809,0.055236,-0.039589,0.057836,0.015040,-0.058839,0.036977,-0.011398,-0.005621,0.051880,0.036341,-0.036455,0.008416,-0.023349,-0.042636,0.004187,-0.007927,0.043317,0.027969,0.061857,-0.014860,0.047895,-0.025565,0.040672,-0.033816,-0.041584,0.048842,0.045519,0.009862,0.025248,-0.024946,-0.011277,-0.023611,0.014308,0.051141,-0.002995,0.055565,0.050156,0.062445,0.007230,-0.014572,-0.001629,0.001564,-0.032527,0.030884,0.014076,0.051131,-0.019634,-0.023851,0.059415,-0.025401,-0.028761,-0.034842,0.045377,0.004189,0.024347,-0.027860,0.007548,0.059762,-0.056017,0.059127,-0.017468,-0.051527,0.064292,-0.027369,-0.023361,-0.030691,-0.005281,0.021765,-0.003281,0.004930,0.026560,-0.013484,0.024959,-0.016957,-0.011893,0.009407,-0.042381,-0.035582,-0.041884,0.037041,-0.037160,-0.056269,-0.012039,-0.041127,-0.053690,0.001350,-0.024134,0.059148,0.005898,0.044979};
  parameter real W257[0:249] = {-0.022638,-0.049892,0.027447,-0.038423,-0.032140,0.045378,-0.003283,0.054152,0.025093,-0.037577,-0.032672,-0.010678,0.041812,-0.046489,0.046654,-0.050390,0.052195,0.026344,0.038879,-0.049743,0.015431,0.013046,0.023566,-0.021375,-0.011462,-0.060543,-0.001651,-0.018230,0.001262,0.017576,-0.015512,0.047617,-0.006335,-0.045369,0.005446,0.005803,0.021242,-0.000358,-0.018302,-0.042803,-0.010327,0.048822,0.046333,-0.015264,-0.002233,0.057500,0.034319,0.022055,-0.058031,-0.040637,0.014952,0.003717,0.015635,-0.017400,0.018770,-0.048924,-0.046988,-0.049884,0.033720,0.055800,-0.062759,0.020419,-0.001988,-0.011210,-0.000190,0.016095,0.036259,0.032721,0.038086,-0.028547,0.011637,0.005926,0.000753,-0.038697,-0.066955,-0.021058,0.003860,-0.047047,-0.008003,0.014472,0.009843,0.058932,0.036188,0.042962,0.039506,0.021092,-0.059014,-0.013435,0.041045,-0.006956,-0.032795,0.032926,-0.036265,0.021622,0.043813,0.048620,0.015051,0.037446,-0.004477,0.024158,0.035947,-0.053361,0.016567,-0.011698,-0.048745,-0.006441,-0.011832,-0.016143,0.012158,0.019669,-0.038939,0.003461,-0.051568,0.001018,-0.062022,0.011512,-0.009211,0.030202,-0.046412,-0.005571,-0.026581,0.053218,0.017206,-0.013598,0.005386,0.020106,-0.014176,-0.013258,-0.006369,0.054604,0.043162,-0.048178,-0.023207,-0.028028,0.055207,0.056759,-0.050234,0.044138,-0.056904,-0.042292,-0.044967,-0.049950,0.038686,-0.036964,0.005920,-0.014830,0.007031,0.049359,-0.052549,-0.065106,0.050075,-0.003520,-0.034680,0.054476,0.036008,0.052451,0.026970,0.012354,-0.028591,-0.056279,0.016571,-0.037042,0.006480,0.050431,0.034787,0.026026,0.024143,0.027442,0.036476,0.026985,-0.005086,0.021441,0.058181,-0.004764,0.044444,-0.029332,0.021681,-0.057472,-0.052258,-0.039321,-0.044580,0.060992,-0.047379,-0.035024,0.022384,0.061499,-0.043543,-0.052588,-0.027844,-0.007403,0.018378,0.051780,-0.003879,-0.047626,0.038640,-0.036897,0.021267,0.020460,0.045844,0.052662,0.061298,0.015841,0.053443,0.025934,-0.020534,-0.038721,0.045729,0.050229,-0.033090,-0.015370,0.021249,-0.026084,-0.049412,0.034730,0.046810,0.026998,0.029304,0.055093,-0.038694,-0.051998,0.035065,-0.009921,0.059481,0.009740,0.022693,0.038845,-0.014871,-0.038315,0.054193,-0.023787,-0.005532,-0.003309,-0.005107,-0.017556,-0.035124,0.000394,-0.033487,0.004879,-0.057270,0.027071,-0.014821,-0.030939,0.006879,0.008860,-0.046629,-0.029142,0.004962,0.034606,-0.057072,0.013586};
  parameter real W258[0:249] = {0.051906,0.051845,0.036579,0.001514,-0.042114,0.013130,-0.032932,-0.039834,0.063402,-0.021688,0.015383,-0.031735,0.025994,0.039196,0.041917,-0.037738,0.015749,-0.049417,0.052061,0.046720,-0.005529,-0.020921,-0.054040,0.052088,0.028484,0.021294,0.025516,-0.001407,0.041587,-0.055055,-0.003582,-0.040160,0.025653,-0.010811,0.012506,-0.024973,-0.021060,-0.017860,-0.052005,-0.053262,0.057994,0.030472,0.007761,0.049809,-0.016679,-0.039768,-0.055720,-0.039733,-0.060381,0.008142,-0.005290,0.025905,-0.003595,0.044534,0.045859,0.040233,0.026122,-0.063280,-0.002748,-0.013867,0.001792,0.048746,-0.027717,0.014851,-0.013329,-0.047210,0.028207,0.048327,0.015115,-0.005346,0.060018,-0.053042,0.023281,0.026451,0.034393,-0.020850,0.003843,-0.037376,-0.013809,-0.039339,0.031756,-0.014845,0.055073,0.007624,0.047678,0.043209,-0.054125,0.062956,-0.010641,0.041555,0.041115,0.042737,0.038071,-0.039205,0.017913,0.017408,0.025413,-0.059516,0.057321,0.014076,-0.048510,0.050785,0.002768,0.047772,0.028266,0.019140,-0.051109,0.032230,-0.002126,-0.037741,-0.004211,0.009924,0.043652,0.039564,-0.051156,-0.012081,0.048620,0.060475,0.043611,0.058887,0.051268,-0.049003,0.027233,0.059646,-0.053946,-0.041767,0.019603,0.011509,0.025549,0.046887,0.038609,-0.048511,-0.042293,-0.023707,0.024820,-0.001380,0.013849,-0.036076,0.021279,-0.047238,0.060630,-0.044405,0.038393,0.009399,0.005277,0.005166,-0.056534,0.038982,0.021964,0.043112,0.053836,0.013289,-0.016953,-0.031041,0.018227,-0.028528,0.058073,0.032502,0.019276,-0.033449,0.018951,0.018491,-0.053115,-0.025658,0.047011,0.026549,-0.002778,0.002530,0.026748,-0.054347,0.032137,0.007275,0.029637,-0.025586,0.040130,0.032245,0.029473,0.052355,-0.019042,0.017327,0.045344,0.000967,0.056348,0.007687,-0.035099,0.017067,-0.005461,0.001481,0.055370,-0.022581,-0.023074,0.025149,-0.058737,-0.051044,-0.047997,-0.044906,0.032467,0.055370,-0.010307,0.054327,0.005647,0.044651,-0.045055,-0.059368,0.011100,0.041172,-0.032540,0.021419,0.008645,0.031770,0.037522,-0.027181,0.045182,0.049159,-0.001405,-0.016256,0.054672,0.012188,-0.021757,-0.012369,-0.034065,0.010429,-0.018755,0.050905,-0.049087,-0.002405,0.015762,0.050654,-0.052955,-0.057946,0.050306,0.057209,0.046443,-0.045838,0.061201,-0.060823,0.004957,-0.035359,0.002909,0.008278,-0.046771,0.038579,0.050766,0.045060,-0.006942,-0.055316,0.049318,-0.054927,0.015718,-0.054324};
  parameter real W259[0:249] = {0.011813,-0.056673,0.036718,-0.034336,0.029160,-0.062775,-0.033918,-0.060448,-0.061044,-0.016700,-0.029488,0.023172,0.036053,-0.012225,0.016461,0.025078,-0.054935,-0.050984,0.017911,-0.061114,-0.047659,0.025844,-0.016227,0.061342,0.005064,0.044431,-0.060873,0.062298,0.017512,-0.023940,-0.056076,0.027368,-0.040435,0.058269,0.043437,-0.010186,0.003381,-0.045611,-0.060473,-0.013227,0.021322,0.030238,-0.000840,0.056811,-0.040645,-0.019610,-0.060822,-0.003126,-0.041459,0.015488,0.007757,-0.020104,-0.033266,0.021697,0.002216,0.025028,-0.053567,-0.021110,-0.020223,0.059796,-0.054880,0.060621,-0.007074,0.056720,0.061740,0.047483,-0.026257,-0.026774,0.001876,-0.060675,0.047332,-0.001975,-0.004853,-0.044132,0.027537,-0.045873,0.009693,-0.011601,0.030524,0.027777,-0.004745,0.032825,0.046705,-0.062498,0.016677,-0.024396,0.049892,0.016007,0.004454,0.016354,0.049674,0.014707,0.061950,0.039484,0.061176,0.045730,0.038781,-0.037327,-0.009949,0.027344,-0.001024,0.030344,0.050185,0.059544,-0.014854,-0.041000,-0.057358,0.005242,-0.002491,-0.017030,0.060477,0.058335,0.022881,0.058636,0.002322,-0.061742,0.028459,0.050461,-0.036989,0.011243,0.007205,0.025058,-0.007689,-0.046489,-0.006683,0.053944,0.046028,-0.041651,0.033990,-0.026468,0.004008,0.043280,-0.002160,-0.049576,-0.004614,0.043913,0.052694,-0.006075,0.017723,-0.015386,0.028667,0.037477,0.047633,-0.023356,-0.051048,-0.001995,0.042974,-0.001361,-0.036863,0.008093,0.004645,-0.046355,0.008633,-0.044815,0.040023,0.059412,-0.000472,0.024709,0.013937,-0.041121,-0.011821,-0.026974,-0.042795,0.003511,-0.008188,-0.002661,-0.026477,0.012689,-0.040788,-0.010758,0.018318,0.035194,-0.066767,-0.032732,0.001940,-0.061779,0.024309,0.030174,0.049198,0.029498,0.021265,-0.057107,-0.026110,-0.003749,0.024117,0.059395,0.009220,0.023958,0.022177,0.031287,0.042254,0.009851,-0.037289,0.006069,0.058559,-0.047229,0.024700,-0.030998,0.017866,0.008545,0.021644,0.052782,0.018625,0.019820,0.012836,-0.049952,0.004752,-0.029064,0.015714,-0.062136,-0.042097,0.027685,-0.045482,0.015169,0.014795,-0.018134,0.061120,0.021305,-0.040421,-0.057500,0.009165,0.008152,0.037226,-0.017090,0.053602,-0.056812,-0.025426,-0.001525,0.051001,0.064985,-0.035470,-0.020395,0.041451,0.024560,0.049632,-0.023178,-0.005897,0.011506,-0.023467,0.044171,-0.034350,-0.012003,-0.037348,-0.011956,0.047362,0.000358,0.045238,-0.002534,-0.018766,0.041244};
  parameter real W260[0:249] = {0.017400,0.014073,0.061567,0.027563,-0.023964,0.048800,0.014907,-0.021285,0.063759,0.051567,-0.038294,0.017371,0.034267,-0.028019,0.030888,0.004327,-0.013957,0.059108,-0.003290,0.037174,-0.050321,-0.014487,-0.031272,-0.007375,0.050244,0.006143,0.015010,-0.012229,-0.001741,0.003626,0.039770,0.048208,0.056571,0.043744,0.024670,-0.010193,0.049305,0.041175,-0.026845,0.019859,0.062122,-0.025488,-0.053299,-0.056028,-0.039103,-0.054472,0.019815,-0.015026,-0.047801,0.009421,0.018799,0.033944,0.038947,-0.007707,-0.015608,-0.024717,0.044761,0.029200,-0.045949,0.027082,0.059923,-0.034413,0.009504,-0.012544,0.004795,0.026637,0.049471,-0.025222,0.052065,0.013035,0.046288,-0.017535,0.035006,-0.005381,-0.025690,-0.015330,0.041767,0.051978,-0.041673,0.000183,0.048614,0.008722,0.008908,-0.014467,0.006243,-0.010455,0.030421,-0.026072,-0.040728,0.000697,-0.041062,0.038853,0.056977,0.014565,-0.057695,0.043881,-0.039431,0.021428,-0.045308,-0.022536,-0.005944,0.056855,0.017672,0.051066,0.002520,-0.039598,-0.015372,-0.025327,0.045094,0.043386,0.036789,-0.046257,-0.063348,-0.032978,0.029319,-0.002386,0.057957,-0.027942,0.047917,-0.045517,0.032685,0.022638,0.028172,-0.009754,0.030182,-0.020506,0.010753,0.053657,-0.048765,0.035810,-0.053090,-0.040780,0.031594,-0.041124,0.020138,0.045628,0.009449,0.010683,0.052676,-0.008635,0.044207,-0.013877,0.038942,0.050785,0.000315,0.036544,0.061141,0.056576,-0.061993,-0.052730,0.030986,0.035929,-0.053329,-0.053722,0.022014,-0.032162,-0.045360,-0.020569,-0.026575,0.051931,-0.050978,-0.061059,0.030627,-0.025184,0.017061,0.061043,0.006896,0.062177,0.045133,-0.008723,0.038241,0.010044,0.027054,0.002044,0.037573,0.011475,-0.035212,-0.012625,-0.000230,0.059548,-0.013553,-0.051931,-0.040718,0.033678,-0.002320,0.033761,0.023453,-0.019511,0.060196,0.032985,-0.045228,0.002364,0.056982,-0.037897,-0.045777,0.017011,0.045829,-0.038869,-0.006384,0.040244,-0.044283,0.035811,0.048873,0.022454,0.005324,-0.060953,-0.031132,0.029035,0.006139,-0.063700,0.014642,0.010281,-0.056116,-0.060212,0.007178,0.028182,-0.055378,0.041794,0.000624,-0.041712,0.054535,-0.057775,0.022320,0.016587,-0.008721,0.064791,-0.026018,0.048964,0.040007,-0.061563,0.005699,0.021849,0.006715,0.036108,0.053535,-0.054034,-0.062535,-0.028843,-0.060916,0.003445,0.058212,-0.053679,0.002713,-0.059001,0.064250,-0.018207,-0.000997,-0.039594,-0.037869,0.000331};
  parameter real W261[0:249] = {-0.038152,0.033268,-0.010884,-0.000771,-0.040465,0.003988,-0.038957,-0.022448,0.028814,0.032315,-0.018752,-0.065363,-0.013003,-0.026150,0.039098,-0.057796,-0.019444,0.015907,0.013271,-0.036651,0.032099,0.039590,0.048374,-0.011190,-0.000401,-0.050105,0.034559,-0.001815,-0.024979,0.023171,0.063938,0.049424,0.028154,0.032731,-0.063125,-0.052959,0.002756,-0.013583,0.059351,0.028872,0.057687,0.027716,-0.031400,0.050247,-0.046764,-0.062288,-0.001967,-0.045529,0.064387,-0.011905,-0.032488,0.011385,-0.036680,-0.042194,0.038327,-0.021669,0.020202,-0.054873,-0.003071,-0.062969,-0.047951,0.017707,0.033428,0.012372,-0.037848,-0.023324,-0.008791,-0.008207,-0.056500,0.020249,-0.021025,-0.005998,-0.036515,-0.044080,-0.031064,0.011129,0.031280,-0.042060,0.060672,-0.000460,0.021440,0.057599,-0.051501,0.049527,-0.050265,0.031156,-0.049786,-0.011698,-0.007188,0.044366,-0.048226,-0.012414,-0.050662,-0.042154,0.025244,0.045789,-0.008896,0.042994,-0.045397,-0.019385,-0.066117,-0.026789,0.009902,0.025081,-0.026526,0.002557,0.051183,0.014147,-0.013234,-0.008933,0.002455,-0.029207,-0.020291,0.049627,0.020593,0.057036,0.018016,-0.015415,0.011402,-0.002577,-0.059008,-0.059476,0.008900,0.024931,0.005026,-0.030207,0.044419,-0.022903,0.002710,0.040087,-0.044588,0.006926,-0.051889,0.022964,0.060235,0.015888,0.009977,0.033477,0.051303,0.051273,0.066027,-0.025368,-0.061750,-0.048685,-0.037315,0.039011,-0.042482,0.008849,0.028439,-0.036990,-0.031744,-0.009367,-0.051348,-0.056439,-0.062336,-0.059063,0.059915,-0.062913,0.020084,0.035495,-0.055043,0.041020,-0.040091,-0.022109,-0.042797,-0.043675,-0.009383,0.015755,0.015811,-0.037547,-0.036442,0.017922,-0.050598,-0.008382,0.005364,-0.013654,-0.047617,0.058670,-0.040849,-0.051448,-0.002836,-0.023219,0.002453,0.003415,0.011406,0.025648,0.032407,0.033461,0.059512,0.054142,-0.052495,-0.019787,0.055751,-0.038185,0.060328,-0.028733,0.053689,-0.046584,-0.026410,0.038735,-0.063935,-0.040230,-0.061442,0.002598,0.047486,-0.045131,-0.054713,-0.061740,-0.051306,-0.006680,0.033158,0.046078,-0.024368,0.010802,0.043619,-0.054072,-0.014674,-0.044979,0.049437,-0.067398,-0.042310,0.057881,0.051257,-0.060963,0.018692,0.031375,-0.040796,0.000742,-0.020428,-0.041520,0.019332,-0.023976,0.043295,-0.043332,0.056066,0.046635,0.032380,-0.048095,0.064920,-0.029722,-0.053611,-0.021161,0.054697,0.047353,0.038176,-0.047090,-0.049320,-0.049906,0.029959,-0.025596};
  parameter real W262[0:249] = {0.006754,0.058151,-0.060204,0.021051,0.055679,0.047048,-0.023492,0.028127,0.019801,-0.053514,-0.051615,0.039591,-0.010614,0.062250,0.040964,0.022616,0.018509,-0.063709,-0.025844,-0.049801,-0.026457,0.030039,0.034919,-0.029835,0.045658,0.010691,0.058792,0.019710,-0.034660,-0.032557,0.038503,0.009485,-0.034975,0.034511,-0.048537,0.048586,0.046888,-0.053833,0.024978,0.044318,-0.050347,-0.036607,-0.063248,0.028599,-0.028800,-0.014518,0.020543,-0.001664,-0.034828,0.020932,0.048120,0.012402,-0.054816,-0.001025,-0.038928,-0.004141,0.055493,-0.053838,-0.024427,0.008402,-0.032902,0.000845,0.061353,-0.011895,0.032794,-0.023431,-0.055412,0.019403,0.001077,-0.003364,-0.017592,-0.032847,-0.057635,0.043908,0.050338,0.039426,0.033654,-0.052082,-0.048374,0.042055,0.053488,0.034293,0.022539,-0.040954,0.006432,0.064077,0.060082,0.029271,-0.006088,-0.011081,0.005683,0.057844,0.016345,0.011779,0.063313,-0.026261,0.047420,0.011644,0.033548,-0.008675,0.057816,0.017780,-0.038703,-0.015888,-0.020867,0.050006,0.068109,0.041473,-0.033856,-0.024828,0.060906,0.039083,-0.059134,-0.041877,-0.053088,0.012688,-0.025326,-0.041988,0.024215,-0.003302,0.010797,0.016021,-0.029186,0.039533,-0.042372,0.028919,-0.044624,0.057274,0.042022,-0.029978,-0.029862,-0.015373,-0.040750,0.038221,0.014713,0.020135,-0.047983,-0.030240,0.011556,-0.055157,0.028947,-0.054258,-0.049762,-0.031075,-0.007990,0.026936,0.052661,-0.038135,-0.022396,-0.023518,-0.046903,0.024087,-0.043012,-0.049801,-0.035499,-0.001974,-0.066117,-0.053887,0.045647,-0.017364,-0.009477,0.015358,0.022721,0.053476,0.047179,-0.021413,0.039073,0.041569,0.061154,-0.007573,0.045035,-0.028928,0.049355,0.054509,-0.046051,0.062582,0.003802,-0.063206,-0.034998,-0.043727,0.025490,-0.024657,-0.001356,-0.023633,-0.044009,-0.044534,-0.060395,0.016318,-0.036067,0.015173,0.025205,0.045808,-0.033452,0.011014,0.029580,0.032538,0.008423,0.063228,0.055821,0.015243,-0.054576,0.029639,0.034956,0.048172,0.001001,-0.037138,0.049548,0.030706,-0.049346,-0.034879,0.046336,-0.010831,-0.042352,0.049807,-0.040927,0.019382,-0.017639,0.049880,0.010835,0.011970,-0.038454,0.038244,-0.007593,0.030319,-0.048492,-0.036036,0.013924,0.039394,-0.031923,0.045869,0.006597,0.007312,0.044286,0.026712,-0.042263,-0.044572,0.008733,-0.015924,-0.040695,-0.053220,-0.056489,-0.013891,-0.037958,-0.043088,-0.005665,-0.019860,0.020072,-0.032841,0.032030,0.056154};
  parameter real W263[0:249] = {-0.044044,0.050775,-0.021101,-0.057783,-0.057563,0.027699,-0.001187,0.023217,-0.046290,-0.051152,0.030695,0.012343,0.019626,0.019296,-0.038953,-0.039938,0.059856,0.065208,0.068519,0.032891,-0.062436,0.017763,-0.032985,-0.010151,0.029480,-0.037068,-0.039476,0.038360,-0.065142,0.021470,-0.049836,0.000768,0.052540,-0.021692,0.025147,-0.004639,-0.065604,-0.001224,-0.045555,-0.034666,-0.063223,0.034108,-0.023555,0.039020,-0.027107,0.029406,0.042375,0.051159,0.068247,0.070020,-0.056516,-0.021010,0.016394,0.034046,-0.040047,-0.054064,-0.006923,-0.022252,-0.050365,-0.006198,0.004119,0.044177,0.056477,0.029755,-0.018929,0.004566,-0.049003,0.047620,-0.032974,-0.031794,0.001872,-0.063904,0.014134,-0.054897,-0.035726,0.014277,0.011738,0.034626,-0.029317,-0.052971,0.053842,-0.047904,-0.063004,0.054205,0.034907,-0.056548,-0.049906,-0.048350,0.029892,0.003800,0.013639,0.043913,0.022533,0.022715,0.006557,-0.015397,0.023519,-0.020262,-0.011975,-0.038788,0.025003,0.005055,0.019098,0.041699,-0.016846,0.019651,-0.000419,-0.030257,0.035126,0.026040,0.020077,-0.044133,-0.064532,0.009557,0.019319,-0.044224,-0.044413,-0.032846,-0.032926,-0.026831,-0.039898,0.055679,0.062064,-0.033192,-0.026988,0.002999,-0.028144,-0.023223,0.015461,0.016256,0.054351,-0.061932,-0.043116,-0.017223,0.018684,-0.060835,0.021554,0.056127,-0.042902,-0.061099,0.033263,0.021373,-0.006878,0.013179,-0.025519,-0.021942,0.019748,0.058366,0.015937,0.053290,0.053069,-0.044198,-0.004269,0.003344,-0.010520,0.048881,0.042206,-0.026150,0.012450,-0.023141,0.010438,-0.065738,-0.017618,-0.007517,-0.051950,-0.057097,-0.030790,0.069843,-0.044396,-0.048773,0.040703,-0.024508,0.034057,0.002196,-0.000011,0.017162,0.025118,-0.035028,0.034378,0.005213,0.038483,0.034849,0.024079,0.043899,0.001974,0.054136,0.040391,-0.049917,-0.036957,-0.015921,-0.032021,-0.070626,0.012811,0.020796,0.036356,0.039463,-0.000885,0.034877,0.004810,-0.012367,-0.031770,0.031248,-0.056373,0.018369,0.005488,0.028563,0.038070,-0.027967,0.045836,0.041113,-0.054734,-0.007823,0.037668,0.055919,0.054759,0.013477,-0.063669,-0.046012,-0.055092,0.054809,0.036685,0.003615,-0.019970,0.057765,-0.058154,-0.040885,-0.043037,0.028855,0.040655,0.004223,-0.011871,-0.008427,0.005912,-0.023096,-0.019199,-0.048180,-0.059414,0.019714,0.041005,-0.036253,-0.012710,-0.057268,0.001365,-0.050430,-0.026085,0.049222,-0.016446,0.077395,0.018176,-0.006664};
  parameter real W264[0:249] = {0.000046,-0.055770,0.033388,0.018273,-0.002410,-0.000770,0.053477,-0.042876,0.041909,-0.026109,0.016716,-0.009003,-0.025351,-0.022203,0.022630,-0.044720,0.050801,-0.063645,0.037253,0.032735,-0.057062,0.049542,0.037441,-0.034083,0.032695,-0.015829,-0.056604,0.027769,-0.048531,-0.021564,0.020837,-0.016873,-0.049782,0.002422,0.041457,0.023611,0.002818,-0.030541,0.051884,0.018774,0.013664,-0.032151,-0.005766,0.049814,0.004047,-0.005854,-0.014331,0.034936,0.008902,0.040164,0.050884,0.048018,0.071437,0.057094,-0.011263,0.049411,0.037560,-0.020407,-0.056665,-0.007641,0.059450,-0.012352,-0.026486,0.004232,-0.001240,-0.060686,0.033000,0.035876,0.002118,-0.048725,-0.046605,-0.055907,-0.028169,0.064144,-0.076050,0.062077,0.022740,-0.000868,-0.000082,-0.054465,0.063651,0.004434,0.043974,0.057903,-0.032602,-0.016203,-0.042176,-0.000223,-0.027338,0.010223,0.027930,0.046690,-0.040780,0.017436,-0.005860,0.062901,-0.027315,-0.003091,0.012917,0.049676,-0.050153,-0.046599,0.042549,-0.045436,-0.035052,-0.055868,-0.004537,-0.045017,-0.048998,0.015942,-0.019746,-0.032488,-0.030715,0.013746,-0.043043,-0.046555,-0.004867,-0.028688,-0.066190,-0.029338,0.049182,0.037188,0.027196,-0.044798,0.013381,-0.031846,-0.042069,0.047162,0.037007,-0.010107,0.034778,-0.025427,-0.055382,-0.002007,0.022493,0.043581,-0.013322,-0.059889,0.015294,0.029550,-0.060977,-0.016623,-0.030400,0.009866,0.037519,-0.010187,-0.040663,-0.043223,0.050974,-0.003004,-0.029081,0.032127,-0.015156,-0.069852,0.030917,-0.023438,0.070625,0.028698,-0.049928,0.029970,-0.008182,-0.030912,0.055780,-0.018631,-0.051309,0.042107,0.049358,-0.022312,0.021415,0.046743,0.016238,0.022746,-0.010355,-0.065101,0.029133,-0.042120,-0.033860,0.056093,-0.037656,-0.055666,0.022384,0.000237,-0.002053,0.055716,-0.010345,0.005956,0.030074,0.044030,0.014812,0.035275,-0.054156,-0.012424,0.052688,0.051345,0.052952,0.046199,-0.028924,-0.054727,0.003498,0.073808,0.032422,-0.055086,-0.004505,-0.060718,0.020706,0.032350,-0.063007,-0.043251,-0.031099,-0.005484,-0.022515,0.016974,0.010477,0.024203,-0.007067,0.048131,-0.023845,-0.051822,0.025772,-0.012593,0.041775,0.011585,0.033610,-0.036445,0.029382,-0.049517,-0.051502,-0.013875,0.027107,0.054691,-0.045246,-0.042938,-0.044620,-0.033042,0.019040,-0.053062,-0.006774,0.029838,-0.050690,-0.031520,0.008928,-0.038917,0.034771,0.034936,0.054489,0.019932,0.009144,0.032875,0.046036,0.023140};
  parameter real W265[0:249] = {-0.043467,0.004692,-0.007595,-0.061247,0.042258,-0.013559,0.031013,-0.006785,-0.042573,0.029681,0.011501,0.015730,0.032711,-0.058340,0.017599,0.015706,-0.057734,0.032250,-0.052302,-0.032571,0.009287,-0.031583,0.025913,-0.021637,-0.037119,-0.004158,-0.004425,0.065413,-0.047451,0.021768,-0.044382,-0.006928,-0.014115,0.002506,0.023835,-0.039915,-0.044792,-0.048844,0.059683,-0.043688,-0.028240,0.017814,-0.038299,-0.052537,-0.049083,0.055461,-0.042321,0.064629,0.041439,0.014465,-0.005743,0.026527,0.006071,-0.020557,0.057795,-0.027783,-0.059677,0.063194,0.030262,-0.006843,-0.056526,-0.008385,0.049321,0.039853,-0.063698,-0.031963,-0.024911,0.023826,-0.009738,-0.059872,-0.054307,0.024590,-0.058160,0.021244,0.003426,0.051012,-0.023032,0.041933,0.057248,0.057517,-0.014680,-0.005541,0.052933,0.076654,-0.038176,-0.001015,-0.042217,-0.021134,0.026424,0.023544,0.060780,-0.058721,0.047745,0.064286,0.014070,0.043757,0.005392,0.007421,0.008085,-0.013474,0.059175,0.000160,0.025687,-0.042995,-0.016999,-0.058627,-0.010204,-0.005021,-0.051736,-0.046050,0.004381,-0.041613,-0.060286,0.031694,-0.022581,-0.022203,0.038008,-0.010362,-0.062073,0.024813,-0.041515,-0.053077,0.024413,0.018845,0.043695,-0.027330,-0.042904,-0.040938,0.034815,0.019184,0.031502,-0.043967,-0.043916,-0.022526,-0.053453,-0.031998,0.065361,0.042112,-0.014348,-0.065588,-0.012207,0.016470,0.000164,0.056400,0.020741,-0.034541,0.034882,0.062545,0.050139,0.009456,0.045781,0.015335,0.054436,0.032728,-0.005331,-0.039315,0.005519,-0.009201,0.060492,-0.023478,0.034724,-0.019375,-0.024096,-0.014057,-0.054473,0.018143,-0.025301,0.055384,0.039579,0.054493,-0.040953,0.056743,-0.039980,-0.016420,0.028249,-0.034290,-0.006899,-0.030603,0.048848,0.049088,0.001519,-0.041109,0.003956,0.035111,-0.004560,0.002845,0.027530,0.047099,-0.029196,-0.010777,0.036996,0.015461,-0.009101,-0.018879,-0.002956,0.013147,0.031260,-0.003210,-0.055135,0.000053,-0.017752,0.048900,-0.033640,0.023812,-0.063411,-0.034148,-0.016727,0.005039,0.020078,0.047302,0.055047,0.025904,-0.019063,0.048461,0.009851,-0.014569,0.045488,-0.003343,-0.024605,0.047541,-0.017134,-0.014211,-0.016783,0.005059,0.044955,-0.027360,0.058759,-0.006973,0.022640,-0.034631,-0.030244,-0.044620,0.024771,0.056962,-0.043697,0.006967,0.047707,-0.056280,0.010479,-0.014832,-0.005465,-0.032077,-0.049013,-0.009638,0.059288,-0.053504,-0.012975,-0.047779,-0.056660,-0.008497};
  parameter real W266[0:249] = {-0.058740,0.061006,0.047158,0.021969,0.061270,-0.008813,0.061456,0.007364,0.006041,0.016463,0.010097,-0.055676,-0.046647,-0.005168,-0.050447,-0.010505,-0.041525,-0.004260,-0.024108,-0.019216,0.063957,-0.052172,-0.019216,-0.042775,0.058116,-0.046225,-0.010763,-0.038492,-0.006576,-0.015034,-0.033375,-0.038924,-0.029966,0.030381,0.036422,-0.028749,-0.048475,0.065680,0.004837,-0.020913,0.061378,0.009884,-0.058514,-0.002044,0.053032,0.012977,-0.045844,-0.052453,-0.005861,-0.012929,-0.017495,-0.011841,-0.031500,-0.037835,-0.065383,0.005586,0.038677,0.053916,0.002681,-0.059009,0.014424,0.011786,-0.045516,0.055379,0.019622,0.062851,-0.018716,0.007915,0.010897,-0.012040,0.027225,-0.022466,0.000310,-0.011747,0.037895,-0.028469,-0.005855,-0.059847,-0.059902,0.057009,-0.065438,-0.058394,-0.004372,-0.021574,-0.059184,0.038072,-0.006869,-0.050786,-0.043290,0.044194,0.061336,0.041273,0.049732,0.033279,0.059095,0.016806,0.010531,-0.051746,0.003357,0.055432,0.031019,-0.004194,-0.047937,-0.023094,-0.028415,-0.046374,-0.017214,0.000204,-0.022688,0.052848,0.013070,-0.056550,0.064151,-0.041147,-0.011932,-0.010860,-0.001117,0.033787,-0.013534,0.054714,-0.044187,0.040874,-0.040614,-0.044580,0.006872,-0.013958,-0.028534,0.019970,0.030472,0.007780,-0.041415,0.059160,0.056426,-0.005337,0.016237,-0.049549,0.036826,0.022194,0.047247,0.059274,0.019678,-0.010227,0.038852,0.022364,-0.050483,-0.002254,-0.053024,0.022100,0.021379,0.060349,-0.012902,-0.000498,0.053968,-0.022323,-0.063431,0.003528,0.003941,-0.018946,-0.022664,0.017709,-0.013993,-0.022933,0.029890,0.013539,0.017543,-0.045097,0.039656,-0.042218,0.045037,0.024558,-0.027529,-0.054148,0.022137,0.020052,-0.059021,0.043125,0.010800,-0.018678,-0.027141,0.013675,-0.055614,-0.052728,-0.012888,0.022116,0.020308,-0.049219,0.037446,0.024751,-0.031796,-0.001787,0.057433,0.000814,-0.004971,0.015303,0.051759,0.042188,-0.031279,0.021361,0.025149,-0.049213,0.012477,-0.023061,-0.042180,-0.044573,-0.038979,-0.053944,0.055136,-0.063282,-0.056742,-0.048452,0.030828,-0.053519,-0.010925,-0.013724,0.055370,0.019206,0.064886,-0.023960,-0.030575,-0.062518,0.047792,0.045436,-0.048653,0.056109,0.008831,0.032139,0.005264,-0.048800,0.033450,0.001887,0.032571,-0.063406,-0.023009,-0.050436,-0.034968,-0.015109,-0.016411,-0.025029,0.013030,-0.009988,0.025758,-0.032065,-0.004626,-0.048104,-0.056476,-0.021775,-0.001577,-0.011341,-0.022027,0.011603};
  parameter real W267[0:249] = {-0.060428,0.009394,0.048546,0.035041,0.064286,0.061450,0.004536,-0.040819,0.018481,-0.026518,-0.034834,0.043453,-0.051688,0.001670,-0.056084,0.002343,-0.037769,-0.023950,0.056396,-0.028425,0.004954,-0.061328,0.053886,-0.007210,-0.008119,0.001802,0.003681,-0.062778,-0.029171,0.062715,-0.025690,-0.055687,-0.040057,0.027260,-0.044669,-0.008344,0.040245,0.035281,-0.061394,0.032330,-0.014434,0.025288,0.003273,0.065241,0.011539,-0.003284,-0.032957,-0.030319,0.039099,0.042734,0.053461,-0.027091,-0.048028,-0.054959,-0.036508,-0.001869,-0.046859,-0.000580,0.047546,-0.045730,0.010057,-0.046575,0.004318,-0.051511,-0.014847,-0.059604,0.035969,0.026656,0.009565,0.028363,0.016646,0.047566,-0.008961,0.019462,0.046481,-0.049985,-0.006034,0.011669,-0.046404,-0.044665,-0.006898,-0.040381,0.034253,-0.054206,-0.051275,-0.026500,0.006250,0.047562,-0.050524,-0.007898,-0.045906,0.007941,-0.047426,0.020308,0.054999,-0.028886,0.003693,-0.025246,0.047430,0.016468,0.031824,-0.029800,0.045759,-0.014745,-0.010249,-0.020261,-0.008987,0.023473,-0.025907,0.029307,-0.027987,0.056823,-0.037533,-0.001274,-0.020656,0.061147,0.024002,0.033403,0.012885,-0.040671,-0.027424,-0.009374,-0.039578,0.032229,-0.044991,-0.016653,0.025945,-0.060950,0.032396,0.026102,0.016443,0.024132,-0.004027,-0.015248,-0.039551,0.064656,-0.042035,-0.053203,-0.049860,-0.052712,0.007149,-0.034230,0.021329,0.051695,0.061987,-0.017235,0.009466,-0.002118,0.039544,-0.031828,0.021661,0.014351,0.010890,-0.025196,0.032973,0.011701,0.003319,-0.003112,-0.047104,-0.010583,-0.029264,-0.007239,0.023594,-0.025644,0.005076,-0.023933,-0.058650,-0.005229,0.013665,0.036116,0.040716,0.024688,-0.054230,-0.015885,0.026311,0.028187,0.046180,0.017485,-0.030568,0.035509,0.059341,-0.007307,0.036337,0.006993,0.011214,0.006039,-0.032754,-0.063108,-0.053353,-0.010821,-0.038712,0.039876,-0.014072,0.032593,-0.046015,-0.019765,0.052150,-0.059227,-0.063410,0.051646,0.051508,0.010000,-0.047908,-0.043996,0.017036,0.018654,0.057908,0.059457,0.022578,-0.031349,-0.007521,-0.019136,-0.007332,-0.005394,-0.007057,-0.058818,0.010289,-0.018218,-0.027957,-0.049423,-0.027335,-0.021729,-0.002076,0.059255,0.045213,0.013639,-0.036254,-0.007131,-0.002905,0.033785,0.008311,-0.025814,-0.033525,0.047516,-0.009762,-0.025122,0.056849,-0.053041,0.048372,0.032755,-0.050402,0.036705,0.014007,0.034812,-0.015851,-0.004819,0.026502,0.040481,-0.000215,-0.015616};
  parameter real W268[0:249] = {0.001357,-0.028331,-0.040449,-0.033623,-0.015629,-0.049351,0.039909,-0.013866,-0.043010,0.016816,-0.025793,-0.023109,-0.054375,0.024394,0.018557,-0.015871,0.038436,-0.012670,0.013298,-0.018720,0.035810,0.051115,-0.054935,0.013777,0.041910,0.022634,-0.017049,0.058653,0.033087,0.050062,-0.037641,-0.040436,0.068985,0.031320,0.026969,0.014878,-0.034184,0.057346,-0.000829,0.052611,-0.000344,0.017305,0.016696,0.013210,0.052241,-0.015388,0.009871,0.012637,-0.009686,-0.039790,-0.021287,-0.011642,-0.034936,0.013607,-0.057102,-0.054743,-0.052624,-0.048034,0.048709,-0.001985,-0.041542,0.010340,0.014434,-0.046416,0.030501,0.051038,0.011473,0.027461,-0.060413,-0.032582,0.013458,0.007006,0.064431,-0.030108,-0.014307,0.062611,-0.025850,0.060714,-0.048125,-0.008617,-0.044122,0.050570,-0.048086,0.037616,0.030391,0.010900,-0.046942,-0.036013,0.054176,0.062742,-0.027217,0.026181,-0.005396,0.010851,-0.014904,-0.017158,0.035306,-0.005897,-0.005663,0.015162,-0.055844,0.003326,-0.016299,0.047875,-0.038930,0.014705,-0.048037,0.032580,0.061090,0.020379,0.033140,-0.044325,-0.017917,-0.060871,0.057028,-0.059861,-0.055468,-0.023335,-0.035854,-0.010636,0.026412,0.010372,0.055827,0.044043,-0.045147,0.068328,0.041541,-0.056147,-0.038996,-0.043370,0.061217,0.026531,-0.000979,-0.053068,-0.007789,-0.053075,-0.013529,0.024556,0.006229,-0.012826,0.008593,0.021305,0.063544,0.052135,0.026419,-0.058221,-0.014696,-0.025248,0.033211,0.014852,0.016080,-0.008331,-0.065106,-0.045428,0.062558,0.047478,-0.045653,-0.038763,-0.009098,0.010704,-0.015615,-0.056725,0.042007,0.056649,-0.040194,-0.014545,-0.025549,-0.026308,-0.060165,-0.034071,-0.033470,-0.008860,0.018566,0.040098,0.062036,0.050709,-0.061827,0.052955,0.043751,0.017926,0.019046,-0.021178,0.035096,0.034484,-0.010321,0.001886,0.058109,0.018459,-0.034923,-0.003681,0.013521,-0.021243,-0.056273,-0.014579,-0.032802,-0.003405,0.042756,-0.053184,0.046854,0.039132,0.038505,0.056812,0.003832,0.023796,-0.039774,-0.054220,0.029615,0.040643,-0.014636,0.018740,-0.031739,0.065529,0.002519,0.003645,0.001221,0.040781,-0.013922,0.012922,0.022044,0.038391,-0.034837,-0.011971,-0.062318,-0.045058,-0.042097,0.041955,-0.060185,0.022393,-0.000212,0.004282,-0.040095,0.031897,-0.056532,0.045937,-0.031912,0.045354,-0.058527,-0.023686,0.027807,0.028583,-0.024666,-0.006918,0.021108,-0.045125,0.021109,0.047710,0.034858,-0.012374,-0.052731,-0.034642};
  parameter real W269[0:249] = {-0.000252,0.032449,0.034511,0.027738,-0.050877,0.045809,0.055100,0.001088,-0.000373,-0.050976,-0.033538,-0.036457,-0.029143,0.016521,-0.040651,-0.053672,0.047204,0.007221,0.012527,-0.001643,0.042512,-0.040691,0.027725,0.033197,-0.051509,0.017493,0.044295,-0.001642,0.043705,0.005845,0.018828,-0.058470,0.053789,-0.022589,0.033857,0.048064,0.024451,-0.015571,0.028256,-0.031245,0.033935,-0.035688,-0.032508,0.025182,0.026129,0.046529,-0.016975,-0.013967,0.024403,-0.023460,0.002629,-0.010937,0.048334,-0.037754,-0.052407,-0.024053,-0.062819,0.028654,0.029527,-0.052134,-0.028093,-0.005836,-0.017543,-0.025755,0.045159,0.012842,-0.043061,-0.001674,-0.016043,0.004507,0.044287,-0.064714,0.065780,-0.022289,-0.028636,-0.019524,0.022156,-0.039312,-0.042204,0.056908,0.013486,-0.057610,0.013830,0.014208,0.017330,0.034107,-0.006902,-0.055586,0.034510,-0.059720,0.038097,0.012667,-0.058702,0.008087,-0.060527,0.004171,0.017822,-0.050310,0.055867,0.036190,0.005596,-0.048095,-0.002831,-0.028787,0.030447,0.062705,-0.016482,0.048883,-0.029239,0.038314,-0.025820,0.030758,-0.048330,0.053659,0.051799,0.035208,0.036987,-0.047315,-0.037256,0.000072,0.023393,0.020659,-0.040693,-0.016219,0.003571,-0.017903,0.010100,-0.011160,0.038992,0.010960,-0.007300,0.064390,-0.001802,-0.000472,0.061525,-0.058500,0.059051,-0.017160,-0.058851,-0.039882,0.041090,0.062286,0.052556,-0.054067,-0.062005,-0.009264,-0.009405,0.025575,0.060823,-0.013747,-0.014516,-0.030376,-0.029624,0.049724,0.000677,0.006177,0.017385,0.013778,0.052617,-0.009375,0.063273,-0.021638,-0.007799,0.049601,0.057786,-0.015672,-0.059915,0.013176,-0.009348,0.065994,-0.014114,0.052068,-0.034373,-0.015968,-0.050078,-0.050179,-0.042843,-0.005343,-0.024612,-0.008861,-0.059964,-0.008381,0.040855,-0.002476,-0.018286,-0.048108,0.029011,0.048753,0.000593,0.025915,0.036894,-0.058017,-0.031313,0.017410,-0.049141,-0.040640,-0.056107,-0.055482,-0.055358,-0.036105,-0.005592,-0.059848,0.005119,-0.061438,0.012773,0.001251,-0.012114,0.006326,0.048372,0.009878,-0.060649,-0.016613,-0.006479,-0.010449,-0.033807,0.007050,0.034499,0.001384,-0.019854,-0.045608,-0.058233,0.021344,0.031878,0.030001,-0.048163,-0.024651,0.061474,-0.032768,-0.036135,0.013457,0.045628,-0.039613,0.048797,0.012837,-0.046205,0.030964,-0.049887,0.022597,-0.032475,-0.000323,0.021279,-0.026260,0.020324,-0.049019,-0.012525,0.040290,0.032348,0.064809,0.039243,0.050570};
  parameter real W270[0:249] = {0.025258,0.057255,-0.005577,0.012805,-0.032763,-0.026830,0.018008,-0.006553,-0.051455,-0.019958,-0.037690,-0.016090,-0.006403,0.051721,0.031008,-0.044451,-0.044434,-0.002310,0.057909,-0.001094,-0.034979,0.053864,0.009671,-0.057218,-0.044626,-0.028433,0.000861,0.034202,-0.029357,0.030513,-0.051851,-0.044112,0.002448,0.015460,0.047978,-0.008291,0.018331,0.017753,0.053532,0.027368,-0.017271,-0.010450,0.016408,-0.032120,-0.007723,-0.040809,0.013165,-0.054798,-0.033546,0.015484,0.037731,-0.002139,-0.032233,-0.007412,0.030397,0.008966,0.039304,-0.028965,-0.025274,0.058141,-0.052063,-0.046269,-0.042687,0.016604,-0.005555,-0.000310,0.025433,-0.011869,0.053395,-0.057360,0.026271,0.028735,-0.021154,0.032379,0.007268,0.015746,0.032916,-0.007123,0.035039,0.025005,-0.040859,0.049284,0.042064,0.024247,0.009841,0.040918,-0.007060,-0.012221,0.029671,-0.043982,-0.004293,-0.053133,0.008005,-0.017935,-0.013569,0.019556,0.048676,0.033621,0.062839,-0.010100,0.001984,-0.042035,0.037534,0.045834,-0.052510,-0.031236,-0.015481,-0.024366,0.037250,0.015833,0.020068,-0.017664,-0.034302,0.022540,-0.019054,0.042533,0.044536,-0.000720,-0.058336,0.026781,0.022392,0.024835,-0.009158,0.049392,-0.034420,0.026102,0.017102,0.043861,0.009616,0.018845,0.000181,-0.013062,-0.045020,0.056950,0.011532,0.040009,0.025165,-0.059783,-0.037412,0.066553,0.010711,-0.006712,0.030466,0.059204,0.042408,-0.011232,0.000123,0.032799,0.051091,0.034649,-0.032186,-0.048074,-0.064853,0.005088,0.017773,-0.008669,-0.029931,-0.020011,-0.021886,-0.013278,0.006120,-0.033526,-0.019743,0.043026,0.014458,-0.037218,-0.046801,-0.012042,0.004643,0.035686,-0.045405,0.053840,-0.055052,-0.049122,-0.032708,0.025756,-0.013486,0.026746,-0.054049,-0.045050,0.021265,0.008854,0.007607,0.010702,0.048406,-0.038370,-0.046012,-0.028986,0.037721,0.049649,-0.009809,0.027113,0.006737,0.000584,0.043343,0.034896,-0.042098,-0.033723,0.057319,-0.019574,-0.057265,-0.045445,-0.053296,0.018274,0.004304,-0.012143,0.015901,0.005144,0.034809,0.014665,-0.001186,-0.012430,-0.022821,-0.037832,-0.023221,0.011391,0.063994,-0.009325,0.058149,0.038850,0.006150,0.007200,0.024375,0.020320,-0.019002,0.039762,0.041870,0.060297,0.047967,-0.031701,-0.006547,-0.005852,0.028552,0.056002,-0.043253,0.055275,-0.004391,0.037726,0.005967,0.026133,-0.061537,0.040073,-0.059046,-0.058117,-0.047711,-0.001120,0.036796,-0.031172,-0.007994,-0.010861};
  parameter real W271[0:249] = {0.059678,-0.040257,0.009955,-0.043011,-0.056293,0.029397,-0.045864,0.064173,-0.032746,-0.001438,-0.007557,0.041152,-0.052154,-0.040917,0.037140,-0.028524,-0.024318,0.051944,-0.033450,-0.055391,0.012353,-0.024944,-0.032914,-0.011460,-0.062115,-0.026925,0.016744,0.012575,-0.022415,-0.062000,0.011594,-0.059608,0.055070,0.007494,-0.005653,0.027999,-0.009366,-0.031391,0.021302,-0.008075,0.031004,0.000948,0.002116,0.046900,-0.022284,-0.063652,0.059458,-0.062040,0.015862,0.002365,0.043229,0.056493,0.008603,-0.026440,-0.032335,-0.001925,0.060074,-0.023572,0.041382,-0.003882,0.000140,0.063598,0.003503,0.050402,-0.055847,-0.049657,0.042182,0.041990,0.023397,0.038089,0.044786,0.036465,0.029025,0.019975,-0.012753,-0.009192,-0.026333,0.044518,0.024457,-0.020038,0.010555,-0.041138,-0.028378,-0.010198,-0.062974,-0.043219,-0.017986,-0.042391,-0.018482,0.028449,0.027502,0.061827,0.000036,-0.014051,0.051234,0.070228,0.019761,-0.045316,0.062162,0.007598,-0.039808,0.016213,-0.055442,0.063219,0.017433,0.023276,-0.062005,0.034589,-0.032667,0.014351,-0.012246,0.055181,-0.005722,-0.046174,0.020087,0.051507,0.034067,-0.016242,0.003485,0.059854,0.062511,0.061419,-0.010029,0.010586,0.022533,0.018204,0.005795,-0.045346,-0.049865,0.009177,-0.053700,-0.018691,0.000187,-0.003333,-0.043590,0.011635,-0.005670,-0.062957,-0.048014,-0.024962,-0.030281,-0.006178,-0.037885,0.019112,-0.037398,-0.044403,0.060702,-0.052781,-0.055008,-0.031110,-0.006667,-0.016563,-0.003833,-0.036332,-0.051362,-0.023351,0.033933,-0.040786,0.036085,-0.036880,0.002246,-0.054742,-0.063722,0.047591,0.042727,-0.006649,0.043714,0.035808,0.054269,0.012651,-0.057225,-0.053946,0.029855,-0.014893,-0.036011,0.059781,-0.035829,-0.048535,-0.009019,0.013725,-0.031176,-0.038791,0.014410,-0.039011,-0.040765,-0.024671,0.063052,0.038261,-0.053858,0.039755,-0.013019,-0.017905,-0.064458,0.059057,-0.037666,-0.056557,0.013763,0.044753,0.014713,-0.025437,-0.036069,0.037943,-0.044935,0.014876,0.043546,0.018992,-0.046695,0.055691,-0.031235,0.060184,-0.042214,-0.054930,-0.011010,-0.025366,0.015182,-0.047892,0.047511,-0.044066,0.042312,-0.029005,-0.005021,-0.039000,-0.058887,0.001036,0.041861,0.040056,-0.038287,0.008241,-0.004044,0.011978,-0.043578,0.031885,0.045295,-0.015613,-0.032032,-0.024491,0.005290,-0.051548,-0.009054,-0.041499,0.017345,-0.046555,-0.039376,0.053050,0.044041,0.058426,0.011546,0.026642,0.041774,-0.038360};
  parameter real W272[0:249] = {-0.031719,-0.007322,0.025113,0.009459,0.064277,0.005337,-0.022713,-0.032401,0.041190,-0.068772,-0.022141,-0.031821,0.004733,-0.063296,0.040607,-0.022939,-0.003932,-0.027701,0.003569,0.020194,-0.019198,0.024658,-0.000291,0.037603,-0.012587,0.010382,0.005952,0.046407,-0.068597,-0.012682,-0.005744,-0.062731,-0.010706,-0.042522,0.043792,0.039277,-0.007557,-0.001794,0.022777,-0.023895,-0.065395,-0.050483,0.014750,-0.002558,-0.021060,0.049851,0.000344,0.023177,0.072534,0.007357,0.015825,-0.042079,0.068378,0.026283,0.039805,0.053315,0.008242,-0.022947,-0.018041,0.069114,-0.044937,0.017525,0.006737,-0.055337,0.036039,-0.054426,-0.057214,0.032346,0.011816,-0.016740,0.012298,0.035423,-0.032353,-0.027942,-0.054501,-0.024554,-0.037710,-0.015968,0.050561,-0.025743,-0.014182,0.032363,-0.047058,0.050568,0.001845,-0.066708,-0.053551,0.008769,0.009708,0.037798,0.066999,-0.064833,0.047343,-0.027472,0.035013,0.073099,-0.005728,-0.052579,0.045654,0.051538,0.021952,0.056258,0.041283,-0.029709,0.015681,0.027196,0.047256,0.029400,-0.016583,-0.000513,-0.003567,-0.034115,-0.047633,0.051203,0.036288,-0.045739,-0.047463,-0.062986,0.045862,-0.054428,-0.022175,-0.021723,0.041533,0.014297,-0.034250,0.020380,-0.058717,0.071113,0.071498,0.057099,-0.029034,0.053220,-0.006024,0.008805,-0.057707,0.044409,-0.042429,-0.027229,0.009211,-0.035248,0.035679,-0.067300,0.023317,0.018529,0.060160,0.038526,-0.049592,-0.001509,0.047341,0.002563,-0.056681,-0.037333,0.041963,0.028026,0.016016,-0.041306,-0.014413,0.009095,0.061465,0.032729,-0.061644,0.007030,0.015247,0.020133,0.035262,-0.037025,-0.004447,0.024577,0.022619,0.042251,-0.002388,-0.054363,0.019753,-0.014790,-0.046566,0.030956,-0.048767,0.011746,-0.042556,0.039218,0.047215,0.007557,-0.054993,-0.002068,-0.046320,0.050467,0.047363,0.017876,0.046298,-0.007052,-0.044999,0.030898,-0.011049,-0.006544,-0.007795,0.003667,-0.008186,0.009031,0.058644,0.013193,-0.010991,0.054228,0.023206,-0.046198,-0.034015,0.067821,0.055297,0.065565,-0.053257,0.069796,-0.055893,0.021273,-0.039340,0.026771,0.067056,0.033337,-0.004540,0.038597,-0.008084,-0.002157,0.009176,-0.042991,0.039672,-0.015263,-0.005464,0.009595,0.053502,-0.026976,0.043085,-0.015833,0.007111,-0.058814,0.047817,0.002246,0.052238,0.011601,-0.047093,0.035899,-0.021252,0.015700,0.043049,-0.023025,0.040141,-0.053580,0.003572,-0.059457,0.022306,0.030029,-0.033349,0.014858};
  parameter real W273[0:249] = {0.014987,-0.047297,0.036200,-0.058735,-0.015360,-0.038946,0.000228,0.052894,-0.052878,0.004187,0.030144,0.058869,-0.006493,0.008869,0.015390,0.036976,0.030672,0.051651,-0.047314,0.038079,0.035168,-0.038811,-0.005811,0.038333,-0.045222,0.015065,-0.035340,-0.007518,0.027848,0.009104,-0.039768,-0.053505,0.004436,0.035135,-0.012004,-0.004199,-0.025462,0.002213,0.042518,0.008838,-0.051889,0.038353,-0.047924,0.061391,0.033179,-0.058509,-0.043489,-0.059973,-0.031220,0.051050,0.043718,-0.019357,0.064768,0.060735,0.024817,-0.041431,-0.016140,-0.042002,-0.062561,0.012124,0.046350,-0.014759,-0.042861,0.045673,-0.040392,0.004067,-0.049525,0.050897,-0.070222,-0.044600,0.057952,0.025259,0.064420,-0.027459,-0.021434,0.045553,-0.021468,-0.025375,0.038824,-0.049041,-0.035177,0.011568,0.006608,0.024081,0.053327,0.057524,-0.037234,-0.067703,-0.005119,-0.017390,-0.023886,-0.054823,0.023923,-0.041230,-0.034003,0.022758,0.004563,-0.031609,-0.061758,0.013204,-0.013053,-0.060179,-0.053545,-0.021050,-0.019895,0.003325,-0.043153,-0.056761,-0.059305,-0.005542,-0.011815,0.017299,-0.028320,-0.014499,0.010061,0.034121,0.035247,-0.050974,0.017063,0.044545,0.043298,-0.029630,0.039233,0.003036,-0.033496,0.022195,0.059073,-0.052806,-0.012510,-0.011403,0.004255,0.005997,-0.026051,-0.046386,-0.061582,-0.033417,0.059000,-0.006068,0.021814,-0.058349,0.039037,0.052025,0.054272,0.017345,-0.007826,-0.048138,0.031319,-0.054914,-0.064496,-0.017532,-0.018155,-0.024132,-0.025998,-0.043211,-0.061755,0.050371,0.046535,-0.041313,-0.043805,0.003784,0.028830,-0.011308,-0.027875,0.010661,0.034853,0.031586,0.003777,0.034510,-0.063794,-0.040764,-0.025884,-0.066092,-0.019339,-0.037907,-0.045846,-0.045015,0.018546,-0.046340,-0.027946,0.003919,0.013560,0.012266,0.023893,0.056059,-0.020829,-0.019604,0.032671,-0.008475,0.018082,0.001381,0.041379,-0.052326,0.042420,0.025062,0.009916,-0.050607,0.034804,-0.009533,0.027611,0.066361,-0.011831,0.048035,0.008733,0.018800,0.020203,-0.037290,-0.050313,0.021646,0.017809,0.029212,-0.068459,0.028481,-0.024166,-0.009984,-0.048774,0.065797,0.039124,-0.002522,0.010989,-0.026135,0.060104,0.058993,0.008902,0.028870,0.056797,-0.040718,-0.035852,-0.026945,0.017673,-0.025757,0.031921,-0.018209,0.032133,-0.022272,0.002942,0.028485,-0.052830,-0.017020,-0.019784,-0.003413,0.005130,-0.035144,0.063989,0.043957,-0.015118,0.050586,-0.023542,-0.005880,0.005228,0.017326};
  parameter real W274[0:249] = {-0.017811,-0.055109,-0.013106,0.027755,-0.035495,-0.053091,-0.039008,0.059301,-0.048524,-0.037560,0.000433,0.015137,-0.007282,0.025437,0.017852,-0.009328,-0.005177,-0.013380,0.050907,-0.061679,0.039054,0.030321,0.019801,0.064789,-0.060361,0.041765,0.059224,0.046923,0.018408,-0.012813,0.035560,-0.038874,-0.016766,0.018620,-0.085879,-0.005813,0.069408,-0.040609,-0.037115,-0.014086,-0.002364,0.057188,-0.021566,-0.001658,-0.002949,0.047268,-0.042909,0.036556,-0.024807,-0.005020,0.041183,0.014007,0.028861,0.005130,-0.011360,-0.003786,0.052164,-0.030240,0.016630,-0.025585,-0.032200,0.001303,0.068000,-0.030932,-0.033149,-0.010509,-0.025210,0.055621,-0.010556,-0.017537,0.013580,-0.000383,0.000755,-0.000498,0.093403,-0.044941,-0.048554,0.057246,-0.033641,-0.019957,0.061041,0.058794,0.030924,-0.052069,-0.011699,0.030505,0.081165,0.041537,-0.028297,0.018624,-0.032122,-0.017266,-0.018224,0.035106,-0.000878,-0.032487,0.023323,0.012034,0.014560,0.021681,0.024743,-0.021287,-0.010185,0.008356,-0.034234,-0.069874,0.066593,-0.000544,0.061378,0.060765,-0.066354,0.045370,0.009961,-0.026515,0.051180,0.001923,0.071188,0.062871,-0.012636,0.051191,-0.049729,-0.035770,0.016428,0.031526,0.035695,0.024165,-0.054212,0.033185,0.035682,-0.028605,0.044647,-0.048051,0.022453,-0.036533,-0.021634,0.049221,0.027647,0.008497,0.026531,0.011162,0.023093,0.042532,0.010511,-0.049449,0.004775,0.040161,-0.010154,-0.028022,-0.024626,0.018197,-0.035402,-0.033179,-0.040938,-0.027275,-0.023628,0.020005,-0.012328,-0.040559,-0.062496,-0.033131,-0.013485,0.048381,-0.050819,0.047565,0.031344,-0.035340,0.054754,-0.015843,0.027631,0.005557,-0.037378,0.060534,-0.050206,0.018554,0.012501,0.058792,0.031555,-0.054520,-0.030988,0.012641,0.034302,0.027727,0.041890,0.016471,0.007751,0.036815,0.041979,0.035290,-0.021180,-0.007595,-0.027947,0.032338,-0.051300,-0.053198,-0.092406,-0.001855,0.041649,-0.036352,0.051410,-0.078142,0.037106,-0.013459,0.049516,0.019111,0.055226,-0.030359,-0.037387,0.042791,-0.030676,-0.019387,0.051779,0.031024,-0.038681,0.039216,-0.033094,0.038595,0.006737,-0.051312,-0.034649,-0.009950,-0.055007,0.053984,-0.014398,0.000937,0.004998,0.001057,0.015115,0.007190,-0.045849,0.004687,-0.024151,-0.007361,0.026496,0.053880,0.030242,-0.050902,-0.037554,0.021574,-0.009508,0.062916,0.022198,0.071047,0.025526,-0.040087,0.050108,-0.052753,-0.058191,-0.029468,0.040323,0.046516};
  parameter real W275[0:249] = {0.052475,-0.015199,0.047842,-0.002063,-0.044738,0.062529,0.021929,0.038718,0.047955,0.029478,0.039846,-0.057789,0.037400,0.047256,0.027142,-0.015954,0.017726,-0.047810,-0.036903,-0.020038,-0.039234,0.001987,0.025839,0.038939,0.011175,0.052443,-0.000034,-0.055641,-0.029110,0.036720,0.004115,0.037769,0.024863,-0.003745,-0.000639,0.008943,-0.007492,0.045629,-0.000529,-0.035824,-0.053489,-0.053483,-0.046934,-0.043440,-0.055904,-0.023911,0.030804,0.000270,-0.032974,0.037837,0.030622,-0.015762,-0.052569,-0.044999,0.003964,0.005990,0.028406,0.045158,-0.019999,0.049400,-0.015294,-0.001854,-0.022086,-0.017895,0.046182,0.054213,0.048426,0.040438,0.047745,0.052618,0.038938,0.031782,0.060868,0.015619,0.071721,-0.055493,-0.052535,-0.024251,-0.028696,0.060434,0.021049,-0.035260,0.027944,-0.061491,0.035829,0.031317,0.048375,-0.048777,0.053663,-0.059252,-0.064420,0.059062,0.026755,-0.036921,-0.017948,-0.042100,0.043651,0.007334,-0.036126,0.028656,-0.011608,-0.046727,-0.010729,-0.044907,-0.005376,0.006848,0.006926,0.008376,0.063271,0.020486,0.024302,0.029617,0.012105,-0.049214,-0.054677,0.014528,0.011382,-0.032355,0.014858,-0.007685,0.038138,-0.017767,-0.012087,-0.026327,0.052216,-0.058832,0.004650,-0.019339,-0.034301,0.040159,0.049827,0.030995,0.035903,-0.004386,-0.011503,0.054876,-0.040098,-0.032206,-0.051033,0.038830,0.027369,0.048253,-0.029656,-0.023130,-0.051190,0.010322,-0.000788,0.042079,-0.042157,0.012390,0.009652,-0.023031,0.027727,0.065017,0.004822,-0.012844,-0.048447,-0.066556,-0.016770,0.024451,0.049438,0.018065,0.036018,-0.007098,0.024161,-0.011559,0.017056,0.017762,-0.008204,-0.020015,0.028904,0.015121,0.054367,0.061934,-0.052729,0.062654,-0.036683,-0.016579,-0.024325,0.050190,0.045801,0.012488,0.028152,-0.047515,0.061945,-0.058639,0.027286,0.026407,0.039616,0.049678,0.031015,0.022008,0.014653,-0.040178,0.035311,-0.045828,-0.033595,0.022924,0.021265,-0.061988,-0.031826,-0.040680,0.028322,-0.057254,0.057289,-0.033177,0.019517,-0.001280,0.064968,0.038692,0.007551,-0.048909,-0.016621,0.060741,-0.049508,0.021716,0.060567,0.014237,0.022292,-0.053067,0.055944,0.001106,-0.038766,0.010669,-0.023789,-0.019396,-0.004231,0.030018,-0.034671,-0.022882,0.030582,-0.052688,-0.041017,-0.009541,-0.052938,-0.006836,-0.035099,0.009389,0.024624,-0.015480,-0.000726,0.004353,0.041087,-0.002025,-0.001102,-0.056425,-0.041924,0.003015,0.037388,0.009876};
  parameter real W276[0:249] = {0.039651,0.012654,0.051928,0.027183,-0.033037,-0.064453,0.040219,0.018009,0.009212,-0.048252,0.034019,0.029315,0.003282,-0.063614,-0.054353,-0.015982,-0.058828,-0.029659,0.020437,0.041097,-0.014951,0.034531,0.009164,-0.015093,-0.040084,-0.017848,-0.043503,0.052034,0.029044,0.015854,-0.012372,0.028662,-0.012417,-0.011205,0.005993,-0.044995,-0.013420,-0.045517,-0.032954,-0.058982,0.009646,-0.051902,0.035418,0.051611,0.014060,0.009705,-0.035853,0.052189,-0.056243,0.052451,-0.037144,0.011561,-0.005944,-0.065509,0.000639,0.043376,0.068292,0.008193,-0.043783,0.043696,0.042361,-0.034194,0.020872,0.021432,-0.031133,0.003463,0.011479,0.043546,-0.025889,0.008236,-0.056715,-0.037601,0.043611,0.057857,-0.014043,0.036877,-0.009153,-0.016357,0.026661,0.067136,0.021460,0.048223,0.011182,0.038464,0.021501,0.001798,0.010815,-0.022258,-0.016432,0.040995,-0.001633,-0.032110,0.011730,-0.052382,0.003639,0.043177,0.030788,-0.013652,-0.053336,0.048346,0.043705,-0.032667,0.062315,0.010902,0.037462,0.026107,-0.048805,-0.038918,-0.035175,-0.005885,0.045257,0.036576,-0.037422,0.058898,0.000166,-0.041545,-0.023685,-0.038363,0.057419,-0.009403,0.007164,-0.026514,0.015036,0.054420,0.005070,-0.005547,0.009391,-0.029658,-0.028591,0.027883,-0.056825,0.041072,-0.051296,-0.014998,-0.064198,-0.055313,-0.018437,-0.032407,-0.053581,-0.018889,0.053794,0.024189,-0.009659,0.031073,-0.061315,-0.006669,0.022576,-0.017245,-0.007323,0.015611,-0.039479,-0.018048,0.048843,0.060295,-0.002644,-0.026005,0.023205,0.023791,0.013742,-0.020742,0.026800,-0.002193,-0.041593,-0.040682,0.022455,-0.054229,-0.053928,-0.044499,-0.023451,-0.047488,0.006033,0.046403,0.054094,-0.019030,-0.047229,0.029362,-0.014823,0.063035,-0.022356,-0.021066,0.038347,-0.010613,0.018340,-0.020656,0.001684,0.064492,0.051383,-0.039245,0.017269,0.050303,-0.059051,0.026519,0.043134,-0.009057,0.052290,0.024921,0.032467,-0.039703,0.030530,0.003432,-0.016792,-0.016404,0.001613,0.012777,0.049549,0.001045,-0.021462,-0.039414,-0.056047,0.035745,0.059848,0.005397,0.004510,0.048952,-0.010473,-0.023487,-0.003217,-0.034255,0.030064,-0.065503,0.045944,-0.035577,0.040421,-0.041708,0.040865,0.032292,-0.017599,-0.029837,0.055001,0.037724,-0.030649,0.057638,0.047115,0.002871,0.023948,-0.048003,-0.018423,0.019025,0.010630,0.034100,0.017255,-0.027668,-0.030124,0.016287,-0.050652,-0.011447,0.037715,0.060046,0.025399,-0.001199};
  parameter real W277[0:249] = {-0.043826,-0.046417,-0.053216,0.041518,0.050151,-0.042665,0.029368,0.056688,-0.012557,0.022346,0.004912,-0.060796,-0.029640,-0.008257,0.046522,-0.041425,0.042117,0.018171,0.018967,0.009762,-0.060923,-0.009928,-0.001392,0.033441,0.039911,0.054021,-0.003522,-0.055164,-0.021498,-0.051412,-0.055444,-0.049882,-0.039729,0.027469,-0.007152,-0.045414,-0.062231,-0.023831,0.021666,0.001989,-0.006216,-0.051501,0.040999,-0.056205,-0.044719,-0.057032,-0.014790,0.049559,0.023316,0.039656,0.021371,0.026798,0.017738,0.038551,0.006767,-0.036158,-0.027141,-0.022240,-0.003195,-0.044240,-0.006459,0.013640,0.062976,-0.030534,0.030377,0.012971,-0.030587,0.066664,-0.026230,-0.029613,-0.011816,-0.058965,0.058620,0.065075,0.015196,0.030933,0.047963,-0.044449,0.066443,-0.014124,-0.013047,0.044940,0.031279,0.004826,-0.035784,-0.040050,0.017340,0.007743,0.022971,-0.012905,0.008987,0.032464,-0.029734,0.042580,0.026454,-0.000659,0.022195,-0.015177,0.031907,-0.028994,0.031179,0.043738,-0.007325,-0.040776,0.039347,-0.014700,-0.063007,-0.047575,-0.023015,-0.054434,0.044096,-0.014525,0.055518,0.038183,0.054477,-0.042697,-0.028053,-0.034012,-0.044922,0.067491,-0.037167,0.007655,0.027889,0.010917,0.053418,-0.043420,-0.006823,-0.027664,0.046678,-0.026729,0.036114,0.011186,-0.007821,0.032875,0.049258,0.061107,-0.043147,-0.045596,-0.057191,-0.014346,-0.018666,-0.040798,0.007096,0.010079,-0.051677,-0.002059,0.013254,0.029547,-0.015059,-0.005573,0.010704,-0.001209,0.008635,-0.027128,-0.018021,-0.022470,-0.015415,0.057177,0.055009,-0.050993,-0.015530,0.019732,0.017248,-0.031622,-0.055805,0.026285,-0.007716,-0.044750,0.017138,0.044302,0.050871,-0.050004,0.012828,-0.037204,-0.053623,0.025556,0.056384,-0.019376,-0.004129,0.024781,0.040514,0.058471,-0.010931,0.058400,-0.016341,0.037826,0.072433,-0.027410,0.034686,-0.001032,0.029228,-0.031381,0.009178,0.034295,0.057695,-0.041687,-0.030773,-0.067418,0.003893,0.059996,0.005299,0.008695,0.016897,-0.058069,0.015876,0.031745,-0.049575,0.017892,-0.012878,0.004435,0.005700,-0.033500,0.005792,-0.052800,0.059973,-0.045958,-0.067294,-0.054525,0.016260,0.049336,-0.021767,-0.016572,0.006225,0.021933,0.011733,-0.027943,0.058079,-0.055089,0.061815,0.065036,0.037836,-0.054243,-0.018539,0.000801,0.031908,-0.000937,0.009934,-0.062309,0.022395,0.014807,-0.013370,-0.064338,-0.030576,0.007653,0.038287,0.000406,0.008657,0.002909,0.034251,-0.048348};
  parameter real W278[0:249] = {-0.059716,-0.036609,-0.003315,-0.031892,-0.047168,0.018107,-0.060624,0.004359,0.039343,-0.015300,-0.001980,-0.049195,-0.053907,0.031436,-0.052587,0.029874,0.053640,-0.004915,-0.014706,-0.043376,-0.054747,0.027104,-0.023082,0.057489,0.033493,0.011055,-0.007414,-0.044715,0.030006,-0.001851,0.008320,0.025943,0.023643,0.056080,-0.038103,0.001414,0.059039,0.019204,-0.049445,-0.020323,-0.050410,0.021610,0.022949,0.005451,-0.005841,0.016024,0.045417,-0.024047,-0.057139,-0.037449,-0.016695,-0.049384,0.032772,0.060965,0.015590,-0.010177,-0.015399,0.000988,-0.061196,0.011913,-0.027905,0.008407,-0.002016,0.035209,-0.031957,0.050097,0.021679,-0.018150,0.057102,-0.008223,0.012601,-0.034919,0.011742,0.023866,0.019184,-0.007617,0.030103,-0.041522,0.066256,-0.017496,0.020042,0.065582,0.067933,-0.051236,0.052851,-0.054913,0.051868,0.037975,0.034745,0.058098,-0.020773,-0.029301,0.043327,-0.062745,-0.050114,-0.065486,0.043878,-0.046704,0.035162,0.005121,0.007604,-0.010691,-0.054677,0.050791,0.061385,-0.012790,0.028230,0.001332,-0.020123,-0.025575,0.007745,0.006132,-0.041462,-0.007433,0.052219,-0.015163,0.068495,0.078103,-0.045264,0.030015,0.048523,0.060509,-0.016091,-0.062016,-0.010666,-0.000726,-0.009813,-0.055004,-0.035911,-0.003177,0.032684,0.040475,-0.064735,0.019336,-0.050583,-0.036931,-0.019245,0.050587,0.051380,-0.012307,0.024114,-0.003674,-0.048211,0.052586,-0.023717,-0.021635,0.024261,0.043678,-0.011469,-0.012850,-0.027175,0.008858,-0.032891,0.036364,-0.052232,0.066657,0.054862,-0.030113,0.051256,-0.020737,-0.044385,0.046120,0.032540,-0.008373,-0.020026,0.048352,0.036704,0.002775,-0.045449,-0.063497,0.020943,-0.014027,0.043208,-0.017541,0.061552,-0.020481,0.034757,-0.054576,-0.018149,-0.034971,-0.059250,0.046980,-0.047654,0.041982,0.010673,0.013656,-0.054854,0.033899,-0.022243,-0.007719,0.010852,0.000434,-0.037330,-0.065812,-0.073460,-0.044805,-0.015935,-0.044159,-0.006599,-0.045523,0.022825,-0.021005,-0.013855,0.012258,-0.071493,-0.006512,-0.068772,0.019928,0.029078,-0.041727,-0.031611,-0.003675,-0.005110,-0.066641,0.041579,0.019807,0.044518,0.001999,0.041968,-0.054306,0.047421,0.032043,0.037610,0.046134,0.029129,0.018898,-0.056088,-0.005966,0.002154,0.052531,0.010464,0.042864,-0.025513,-0.043722,0.022540,0.031051,-0.054855,-0.064907,-0.000891,-0.023072,0.045044,0.040905,0.002931,0.045726,0.066142,-0.017792,0.056568,0.044372,0.039926,0.053922};
  parameter real W279[0:249] = {-0.015753,0.052230,0.001339,0.002382,-0.054385,0.010581,0.058707,0.016074,0.025716,0.048561,-0.027891,0.038365,-0.008270,0.048295,0.040183,0.040695,0.009996,-0.020564,0.029794,-0.017709,-0.051708,-0.001076,-0.020092,-0.010769,0.021994,-0.023875,-0.028940,-0.053904,-0.006260,0.036746,0.032997,0.018114,-0.043850,-0.000535,-0.016198,-0.061935,0.031120,0.022341,-0.009519,-0.049884,0.008981,-0.046750,-0.045348,0.036592,-0.021742,0.054591,0.058555,-0.034592,-0.054780,-0.027952,-0.033642,-0.061851,0.044561,-0.015132,0.012773,-0.061037,0.044968,0.015813,0.055546,-0.008103,0.038410,0.050465,0.055366,-0.060150,0.050949,0.003107,0.049717,-0.050039,-0.042955,0.017802,-0.041178,0.005716,0.059226,0.018462,-0.006715,-0.010412,0.014324,0.004048,-0.023318,-0.050694,0.034970,0.041605,0.036273,0.028796,0.041996,0.029339,0.053380,0.061356,0.008001,-0.036715,0.021761,0.050969,-0.041973,-0.024591,0.027820,-0.050293,0.049141,0.022451,0.054782,0.029668,0.008411,-0.037466,-0.007743,0.043251,-0.008018,0.047840,0.028945,0.038600,-0.009047,0.023725,0.003104,-0.056850,-0.042921,0.054684,0.055592,-0.049733,0.049689,-0.032332,0.049789,-0.059475,-0.011686,-0.059754,0.056739,0.050717,-0.057579,0.002411,-0.057234,0.041083,-0.061867,0.039714,0.034390,0.064026,-0.053921,0.006367,0.039346,-0.011527,0.050405,0.048623,0.045495,-0.028398,0.007886,0.046316,-0.031951,0.056975,0.059074,0.050889,0.007762,-0.028571,-0.033823,0.001768,-0.050014,0.049794,-0.026030,-0.056544,0.042089,-0.037207,-0.037964,0.022507,0.038587,0.037648,0.032648,0.011390,0.019854,0.026125,0.033128,0.021284,-0.040194,-0.019839,-0.051531,-0.002056,-0.057347,-0.017927,0.000206,0.052010,-0.062092,-0.051348,-0.014011,0.055568,-0.019472,-0.052565,-0.007693,0.049279,-0.055975,0.052177,-0.009272,0.028357,-0.024715,-0.004651,0.015550,-0.015917,-0.029895,0.004584,0.017993,-0.020420,-0.003056,0.008857,0.049001,-0.005398,0.040553,0.012389,-0.042901,-0.043249,0.043944,-0.022289,0.029771,0.051036,-0.029722,-0.016193,-0.031394,0.038531,-0.046166,0.021516,0.023900,-0.055140,-0.003787,-0.032234,0.027555,-0.015782,0.048862,-0.006698,0.029877,-0.001177,-0.040658,0.037639,0.056371,-0.039765,0.043306,-0.059076,-0.010572,0.026860,0.002658,0.009341,0.057337,-0.003889,-0.004592,0.051258,-0.043657,-0.014007,-0.042417,-0.020077,0.006508,0.031695,-0.032698,0.062444,0.057139,-0.030306,-0.000839,-0.038498,0.038572,-0.056373};
  parameter real W280[0:249] = {0.015072,0.022165,-0.001486,0.048847,-0.062980,0.029012,0.065516,-0.027042,0.068138,0.027026,-0.041733,0.033329,0.006015,-0.026543,-0.054594,-0.006718,0.016801,0.044589,-0.044025,-0.011876,0.007450,0.036156,0.066266,-0.052390,-0.001456,0.055196,0.061154,-0.023902,-0.044977,0.027234,0.019478,0.010196,0.042081,0.047892,-0.039281,0.025342,0.021960,-0.021170,0.003465,-0.042597,0.041770,0.014749,-0.005573,-0.045115,-0.007571,0.039180,-0.030051,0.003061,-0.047579,0.017821,-0.022505,0.011534,0.041334,-0.030071,-0.010577,0.054182,-0.023141,-0.063212,0.011145,0.026192,-0.002332,0.020373,0.023628,-0.046823,0.040457,-0.004739,-0.029682,-0.035624,0.033091,-0.025985,0.034599,-0.002102,-0.002131,0.039581,0.052438,-0.051397,0.010514,0.048155,-0.047070,-0.009089,-0.047114,0.065562,0.061116,-0.057110,-0.041116,0.000427,0.006580,-0.050774,-0.049520,-0.036598,-0.004932,0.048333,-0.007466,0.010665,0.003068,-0.064726,0.015065,0.043186,-0.027666,0.041684,0.054883,-0.002584,-0.008109,-0.027710,0.011875,-0.064234,0.009248,0.052688,-0.045427,0.033478,0.053360,0.009650,0.031337,0.005644,0.003971,0.019344,0.005778,0.036820,0.018750,-0.052118,0.021231,0.028474,-0.073619,0.003000,-0.040978,0.033721,-0.015480,0.047280,-0.022999,-0.031668,-0.000121,-0.001578,0.038682,0.065003,0.052666,0.031049,0.033736,0.055895,0.069650,0.003375,0.004744,-0.010881,0.051355,0.024079,-0.014150,-0.036618,0.047814,-0.020485,-0.041185,0.047755,-0.051590,-0.024005,0.012179,0.056250,-0.009269,-0.032648,0.047429,-0.068203,-0.011121,0.063485,0.047773,0.007941,-0.059499,0.030091,-0.020866,0.050817,-0.043789,0.057025,-0.045260,-0.012246,-0.043174,0.022723,-0.047261,-0.041611,0.054796,-0.062660,0.057943,-0.024809,0.053215,0.034111,0.010960,0.030313,0.058222,0.062510,0.040577,-0.046944,-0.032818,-0.004717,-0.038732,-0.054898,0.027278,0.055350,0.029530,0.011141,-0.085581,0.051822,-0.033480,-0.028522,-0.055728,-0.073915,0.042010,-0.026533,-0.014575,-0.035348,0.039008,0.054973,-0.033045,0.029682,-0.003800,-0.009938,-0.013531,-0.033002,0.018848,0.053379,-0.044814,0.028673,-0.063611,-0.017166,-0.034137,0.033023,-0.014718,0.068573,-0.054530,0.066963,-0.015368,0.020996,-0.055713,0.023661,0.008374,-0.038407,-0.055250,0.060206,-0.010424,-0.059554,-0.068208,-0.013347,-0.056225,-0.041089,-0.019013,0.057430,0.057507,0.061202,0.000000,0.057071,-0.013247,0.054584,0.003535,0.021449,-0.052055,-0.001101};
  parameter real W281[0:249] = {-0.060469,0.034985,-0.054653,0.034939,-0.003918,0.026959,0.016045,-0.005575,0.016706,-0.044741,-0.003444,-0.070473,-0.004575,0.034000,-0.039569,0.026183,0.016134,0.009456,-0.028238,-0.042621,0.034057,0.012230,-0.038387,0.013603,0.065257,0.018921,0.038037,-0.026305,-0.022149,-0.064514,-0.027156,0.004121,0.054145,0.063931,0.030789,-0.014716,-0.010847,-0.025541,0.073424,0.005819,0.036998,-0.041516,-0.019177,-0.046294,0.046345,0.033030,-0.001648,-0.056200,0.067513,-0.057817,-0.012378,0.004255,0.019328,0.004877,0.001967,-0.025120,-0.042735,0.078534,0.043754,-0.005562,-0.001668,-0.035463,0.021804,0.022706,-0.034831,-0.002694,0.035716,-0.044803,-0.005294,0.035241,-0.058556,-0.042238,0.006292,0.050788,-0.073468,0.061063,0.057597,0.018697,0.042506,0.055140,-0.018291,-0.004822,-0.053175,-0.017819,0.039055,-0.017667,0.009996,0.047474,0.019903,0.017370,-0.025890,-0.034283,0.035865,0.044975,-0.015041,0.074901,-0.005643,-0.022798,0.043763,-0.057286,-0.039950,-0.018978,-0.037791,0.026165,0.032921,0.058199,-0.014588,-0.054312,-0.034659,0.034067,0.050321,0.014750,-0.004672,0.001229,-0.018066,0.038597,0.006783,-0.011425,-0.035860,0.000822,-0.042188,-0.057625,0.062328,-0.047318,0.045027,-0.030815,-0.042533,0.044225,0.031030,0.016166,-0.060256,0.003234,0.044768,0.035984,-0.009221,-0.006818,0.043475,0.036885,-0.018887,0.051179,0.008738,-0.028022,-0.056718,-0.021910,0.026990,-0.041032,0.030326,0.073291,-0.007448,-0.002051,0.025429,0.009102,0.044066,-0.026751,0.061557,0.045083,0.007235,0.070689,-0.011951,0.006431,-0.057740,-0.041946,-0.029985,0.022108,-0.028495,-0.026443,-0.031862,-0.042656,0.052467,-0.004214,-0.070081,-0.065892,0.038822,0.040023,-0.001931,-0.039042,0.005681,0.046035,0.000291,-0.006323,0.062880,0.048080,0.032022,0.013984,0.026743,0.019426,0.001304,0.045268,0.045747,-0.011481,0.048056,0.029485,-0.038358,-0.050388,0.087341,-0.016471,-0.034347,-0.046116,-0.051931,0.019439,-0.032517,0.013978,0.001707,-0.046189,-0.008085,-0.005996,-0.059132,0.055176,-0.004079,-0.003203,0.006557,0.060076,-0.039596,0.013690,-0.009224,0.061363,-0.049548,0.034465,0.036898,0.064655,0.019900,0.025732,-0.059382,-0.048212,0.029934,-0.005843,-0.006787,0.004065,0.016704,-0.010858,-0.054194,-0.004322,0.031355,-0.013673,0.027037,-0.044190,0.020590,-0.024026,0.031982,0.014715,0.028152,0.020987,0.036195,0.051978,-0.028586,0.069954,0.028105,0.010305,-0.030747,-0.009087};
  parameter real W282[0:249] = {-0.031746,0.039122,0.018653,0.030780,0.006005,0.061019,-0.063010,-0.026730,-0.006963,-0.041662,0.037574,-0.057598,-0.042695,0.000702,0.048762,-0.044137,-0.047844,0.009535,0.034277,-0.001443,-0.014711,0.001903,0.038366,-0.020768,0.049040,0.044624,-0.030458,0.045397,0.003112,0.060820,-0.006808,0.032421,-0.030835,-0.026591,0.000902,-0.063005,0.043725,-0.061378,-0.045111,0.058921,0.026072,-0.017600,-0.008752,-0.023019,0.035046,-0.050632,0.004530,0.000370,-0.010425,0.010287,-0.028206,0.045159,0.017537,0.016907,-0.044132,0.045946,-0.008246,-0.001837,0.024360,-0.022998,0.041447,-0.003118,-0.053194,0.032112,-0.021044,-0.021029,0.052458,0.003714,-0.055742,0.028019,0.026176,-0.029949,0.058554,0.031777,-0.045374,0.073280,-0.000706,0.043881,-0.018762,-0.039222,-0.011365,-0.046302,0.050290,0.056138,-0.043559,-0.032554,-0.053511,0.022012,-0.027206,0.043485,-0.009608,-0.044462,-0.028971,0.013817,0.038756,-0.004766,0.022645,0.009540,-0.048890,0.006935,0.036041,0.030132,0.043453,0.057557,0.064688,0.031063,-0.057836,-0.025602,0.003805,-0.063984,-0.027250,0.001870,-0.051233,-0.043041,-0.005080,-0.056303,0.036454,-0.010758,-0.044997,-0.003508,0.058351,0.015474,-0.011073,-0.034351,0.020899,-0.034200,-0.046440,0.049455,0.018156,0.044504,0.002251,-0.056515,0.020771,0.063092,-0.019760,-0.001245,-0.030602,0.034065,-0.035322,-0.054087,0.050939,0.043065,0.067291,0.031529,-0.054180,-0.022135,-0.052404,0.061986,-0.053611,0.036205,0.001330,0.050044,-0.051197,0.012716,-0.016373,0.058842,0.017915,-0.060549,0.014759,-0.028543,0.044665,0.041708,-0.038792,-0.050254,-0.050799,0.001873,-0.021209,0.017703,-0.022563,-0.028338,0.015492,-0.045323,0.035603,-0.070603,-0.025431,0.009561,-0.009309,-0.006015,-0.059728,0.031487,-0.054769,-0.020281,-0.036360,-0.012173,-0.009450,0.002705,0.052310,-0.044212,-0.056645,0.021086,-0.041385,-0.070469,-0.037724,0.008790,-0.028417,-0.043471,-0.058490,-0.025238,0.007780,0.064164,-0.054480,0.010430,-0.003198,0.050305,-0.017723,0.053854,-0.034020,0.058910,0.059056,-0.047199,-0.009184,0.059273,-0.043223,-0.011247,-0.002031,0.007579,0.026057,-0.044483,0.023525,0.060905,-0.046208,-0.023055,-0.000328,-0.001746,0.049422,-0.052586,0.030255,0.051657,-0.034710,-0.048855,0.035120,-0.018879,0.009047,-0.018765,0.011276,0.044455,0.045595,-0.012017,0.016695,0.002273,0.050391,-0.022412,0.037782,0.020667,0.047319,-0.063211,0.014139,0.053986,0.020410,-0.028379};
  parameter real W283[0:249] = {-0.084543,0.028232,0.012557,0.024937,0.012662,0.011996,-0.072026,-0.027068,0.052754,-0.023886,0.060350,-0.066504,-0.026725,-0.036600,-0.030026,-0.026250,0.021967,0.024617,-0.034028,-0.020028,-0.037282,0.007554,-0.028096,0.045616,-0.060611,0.063526,0.005750,0.063251,0.012770,0.000724,-0.035227,-0.042776,-0.041105,0.006689,-0.068858,0.026043,-0.031813,0.032490,-0.047987,-0.019090,0.054129,-0.007050,0.026663,0.046136,-0.040904,0.054259,0.027452,0.003631,-0.004621,-0.057109,0.067540,0.066254,-0.064400,0.013170,-0.026476,-0.019386,-0.062334,-0.031946,0.032497,-0.033298,0.051966,-0.082306,-0.016525,-0.001712,-0.053196,0.004832,0.023581,0.010203,-0.027807,-0.069597,-0.079390,0.005507,0.033183,0.015541,0.026861,-0.035201,-0.052330,0.030439,0.023750,-0.018550,-0.030574,0.054406,-0.001812,-0.055396,0.054353,-0.003287,0.040720,-0.035171,0.075292,-0.035798,-0.031894,0.013147,-0.024357,0.038602,-0.016395,-0.051853,0.002621,-0.052633,-0.055242,0.022797,-0.019091,0.019415,0.023700,-0.086220,-0.059840,-0.057340,0.093399,-0.058131,0.074886,-0.001692,0.024019,0.031882,0.036763,0.009958,-0.062288,-0.009897,0.013056,0.091291,0.009020,0.058217,-0.032129,0.015433,-0.071069,-0.063625,-0.006000,-0.014984,0.046739,0.062811,0.006009,0.025647,0.037550,0.075115,-0.011570,-0.068611,-0.011755,-0.040628,-0.045281,0.044078,-0.069301,0.027110,-0.028062,-0.050248,0.000767,-0.020661,0.005235,-0.003674,0.034249,0.021333,0.043747,0.057627,0.005022,0.074673,0.049097,0.100771,0.074666,-0.012666,0.023007,0.052139,-0.021756,0.024269,0.019608,0.055834,0.012680,0.043903,0.001126,0.058861,0.078871,0.031467,0.013293,-0.048125,-0.063737,0.041318,0.062145,-0.014694,0.060675,0.033792,-0.013940,0.048197,-0.021447,0.055782,0.052510,0.078746,-0.026277,0.041055,-0.063401,-0.048855,0.058230,0.071341,0.008438,0.009547,0.032174,-0.039608,-0.063778,-0.052152,-0.047123,-0.026703,0.006670,-0.076629,0.041190,-0.092996,0.000797,-0.011579,-0.027143,0.029925,0.011368,-0.051849,-0.004513,-0.057779,0.020555,-0.029246,0.056287,0.043193,0.006058,-0.073794,-0.077768,-0.052983,0.014781,0.025702,-0.026343,0.038218,-0.042358,-0.043944,-0.012814,-0.073620,0.018359,-0.031872,0.000699,0.018378,-0.043926,-0.033938,-0.034701,-0.031395,-0.038731,0.069310,0.046593,-0.048021,-0.033354,-0.075915,0.003316,0.048210,-0.014543,0.001143,0.025321,-0.010615,-0.053288,0.018970,-0.003821,-0.063692,0.038713,0.040590};
  parameter real W284[0:249] = {0.012693,-0.014330,0.007484,-0.029861,-0.060023,-0.023608,0.022296,0.007681,0.061368,-0.027107,-0.024295,0.003593,-0.012246,-0.045980,0.014921,-0.036595,0.056627,0.025679,0.043053,0.060682,-0.021716,-0.039345,0.007889,-0.036952,-0.013357,0.038970,-0.043741,-0.008777,0.028406,-0.012134,-0.061521,-0.032528,0.035709,-0.046766,-0.016134,0.019164,-0.026685,0.020359,0.022046,-0.036802,-0.020490,-0.013633,-0.039842,-0.029446,-0.001193,-0.041718,0.056780,-0.061789,0.034989,0.039257,0.042938,-0.007249,0.006621,-0.049565,-0.026184,-0.056553,-0.016808,0.011896,0.020080,0.055963,0.056170,-0.018769,0.024009,-0.056851,0.000893,0.021580,0.046666,0.027777,-0.008008,-0.001087,0.046773,-0.041234,0.050565,0.003253,0.010171,-0.012234,0.035568,0.061592,0.062399,-0.061728,0.051080,-0.031045,-0.009238,-0.004557,0.003359,-0.055279,0.000294,0.036470,-0.045471,-0.039532,-0.024865,0.054311,0.023106,0.022063,0.037750,-0.034610,-0.010146,-0.002994,0.052661,-0.004616,0.056138,0.059338,0.034225,-0.024126,-0.002947,0.061035,0.038287,0.040502,-0.008918,0.049536,0.059684,0.000133,-0.043590,0.065555,-0.028379,-0.030858,0.008867,0.015607,0.061140,-0.057245,0.018053,-0.002662,-0.050501,0.024617,0.044213,0.008373,-0.032192,0.037777,-0.061121,0.057181,-0.047153,0.060165,0.058797,0.032422,-0.039732,0.054469,0.032418,0.030286,0.045188,-0.008082,0.047192,0.037865,-0.037793,0.000330,0.058827,0.033004,-0.023961,0.031152,-0.003067,-0.053009,0.021725,-0.030701,0.048040,0.031942,0.042306,0.048868,-0.061427,-0.050782,0.007352,0.032797,-0.062341,0.060824,-0.017080,0.011777,-0.045620,0.018868,-0.037855,-0.053101,-0.033276,0.054362,0.044539,-0.055951,-0.048758,0.054004,-0.030727,-0.063081,-0.006660,0.015804,0.032944,0.051128,0.053607,-0.004462,-0.029192,0.024094,0.056638,0.033437,-0.019755,0.018753,0.057351,-0.009784,-0.031710,0.036160,0.055892,-0.022459,-0.034735,-0.037025,0.052319,0.018796,-0.013219,-0.042195,0.053289,0.027743,-0.026526,-0.052883,-0.011931,0.062955,0.008783,-0.059693,-0.019024,0.053872,-0.055826,0.013709,0.047741,0.019209,-0.021162,-0.035408,-0.034725,0.038040,-0.021439,0.037789,-0.036066,0.044078,-0.051358,-0.028812,0.048905,0.012191,0.001058,0.008672,-0.010311,0.001347,0.006616,0.064401,0.040943,0.050147,-0.051907,0.007905,-0.010051,0.018945,-0.057646,-0.011498,-0.045204,0.022116,0.061288,0.046922,0.014997,0.021946,-0.023423,-0.059196,-0.019640,0.046259};
  parameter real W285[0:249] = {0.015119,0.011114,0.059954,0.055159,-0.029098,-0.029181,-0.041080,0.027760,-0.054989,0.020219,-0.042967,-0.054674,0.024533,0.000170,0.056391,-0.004641,-0.054927,-0.038443,-0.048992,-0.029413,-0.061097,-0.016569,-0.062193,0.049141,0.045982,0.049280,-0.048569,-0.002397,0.051486,-0.040690,0.053767,-0.032249,0.049768,-0.038858,-0.016914,-0.018046,-0.017077,-0.009553,-0.047058,0.046063,-0.015177,-0.012819,0.021742,-0.014736,-0.024937,-0.017003,-0.006593,-0.063410,0.058807,0.015163,0.031840,0.038802,-0.017493,0.037389,0.027026,0.017450,-0.026362,0.026685,-0.002503,0.013128,0.018749,0.040345,-0.004828,0.029353,-0.061428,-0.028961,0.006772,-0.050120,-0.038018,-0.024693,0.032734,0.045108,0.050617,-0.023933,-0.044621,0.014621,0.012581,-0.053397,0.016398,0.012121,0.025184,0.020165,-0.001573,0.006382,0.049071,-0.019011,-0.008223,0.024022,-0.046689,0.019603,0.004313,0.048082,-0.053801,-0.038064,-0.042781,0.034291,0.039391,0.013617,0.000608,-0.050941,0.002537,0.027852,-0.008691,0.004696,-0.011557,-0.056032,-0.059955,0.041193,0.056837,-0.048997,0.024285,-0.032455,0.010429,-0.021744,0.020414,0.019070,-0.007216,-0.015081,-0.009122,-0.052496,0.023961,0.007360,-0.024794,-0.031613,0.065502,-0.028575,0.045211,0.008586,-0.003295,-0.056280,-0.041703,-0.039107,-0.048953,0.047878,-0.051470,0.038055,-0.030181,0.053502,0.010417,-0.023542,-0.031568,0.054088,0.044888,0.004917,-0.034324,0.015271,-0.026338,0.060945,0.063021,-0.002801,-0.024183,0.021661,-0.006266,-0.044305,0.042925,-0.025211,-0.011842,0.044640,-0.057722,-0.023957,0.056133,-0.019707,0.062759,0.017612,-0.058763,0.007491,-0.035562,-0.057189,-0.021770,-0.003662,0.014146,0.004447,0.008341,-0.052452,-0.022272,-0.061344,-0.051954,-0.045299,0.058313,0.037876,-0.054471,0.060272,-0.038222,-0.049418,-0.013584,0.057303,0.033892,0.020387,-0.021424,0.014960,-0.042640,0.006862,0.034467,-0.051179,0.005258,-0.002765,-0.012479,-0.049966,-0.010032,-0.023902,0.058875,-0.046594,0.007902,0.050083,0.028718,-0.011646,0.022911,-0.000332,0.012313,0.032467,-0.014621,-0.045576,-0.009224,-0.010413,0.056515,0.055036,0.005611,-0.032379,-0.022945,0.048502,0.057305,0.036481,-0.002135,-0.008018,0.018964,-0.008871,-0.037650,-0.009605,-0.029661,0.059020,0.010904,-0.024653,0.037418,-0.053221,-0.064701,0.026644,-0.036820,0.004725,-0.058766,0.025820,0.039671,-0.029773,-0.034368,0.033070,-0.049696,-0.058144,0.029359,0.046588,0.046956,0.041499};
  parameter real W286[0:249] = {0.056952,0.016088,-0.028053,-0.045960,0.025754,-0.046740,-0.019338,0.025153,-0.073008,-0.074247,0.002309,-0.022682,0.039730,-0.026002,-0.014412,0.033234,0.021795,0.070070,-0.015844,-0.017425,0.052711,-0.062030,-0.020142,0.055528,0.020957,0.042664,0.050858,0.028208,-0.043258,0.033382,0.061656,0.031675,-0.016409,0.011812,0.039516,0.027848,-0.079578,0.009062,-0.041900,0.009038,-0.061547,0.057919,-0.049187,0.002916,0.028243,-0.057671,0.015559,0.018698,-0.020256,-0.048035,0.032967,-0.008149,0.052062,0.013820,0.032500,-0.046637,0.064685,0.009265,-0.012065,0.062004,0.008564,-0.011943,0.043885,-0.065292,-0.079025,-0.056656,0.059237,0.021797,-0.038214,0.042174,-0.034723,0.015942,-0.056583,-0.037052,-0.067995,0.070038,0.011159,0.030229,0.011250,-0.041221,0.042293,0.059776,-0.018821,0.064389,-0.020387,0.022777,-0.048300,-0.026996,-0.014663,0.018933,0.012813,-0.027238,-0.015138,0.078492,0.000574,-0.026952,-0.057003,-0.044888,-0.029945,-0.008831,0.005069,-0.027364,0.067684,0.050576,-0.030269,-0.057405,0.001887,-0.039755,-0.055509,-0.006603,0.032833,-0.046952,-0.059478,0.029792,0.027700,-0.004529,0.016165,-0.027868,-0.019339,-0.037206,0.083318,-0.016269,0.049833,0.011499,-0.010230,0.029928,0.018023,0.028330,0.018862,-0.006956,0.016481,0.014898,-0.040844,-0.007754,0.017335,0.007220,0.050224,-0.015885,-0.039383,0.005174,0.019820,0.051615,-0.054898,-0.057466,0.021259,-0.043857,0.022566,0.032963,-0.044926,-0.042129,-0.029738,-0.086821,0.073486,0.019814,0.011093,-0.062085,0.018873,-0.032968,0.063729,-0.052897,-0.034904,0.042960,-0.008156,0.028293,0.001436,-0.054389,-0.044532,0.026236,0.038029,0.031906,-0.043019,-0.054229,-0.031826,-0.072959,-0.053094,0.006242,-0.088588,-0.027127,-0.010121,0.058241,0.065114,0.044367,-0.032583,-0.018090,0.018869,0.051489,0.045664,-0.063903,0.001113,-0.009546,0.031981,-0.056342,-0.045754,0.016584,0.075862,-0.056897,0.047012,-0.054782,-0.001269,0.058943,-0.024023,0.023341,-0.052028,0.063211,0.000486,0.004138,-0.062671,-0.015644,0.057806,0.001366,0.033114,-0.066306,-0.052780,-0.024397,0.021536,-0.020863,-0.038358,-0.026166,-0.015015,-0.029110,-0.052575,0.018405,0.034395,-0.001885,-0.018544,-0.012437,0.026993,-0.054719,0.048448,-0.033006,0.051557,0.011126,0.017698,-0.061332,-0.053910,-0.006562,0.007809,-0.065103,0.048786,0.051405,0.007022,-0.044921,0.034191,0.044553,0.020675,-0.016160,0.044646,-0.008830,0.025022,0.016701};
  parameter real W287[0:249] = {-0.038676,0.037612,-0.047996,-0.004620,-0.056068,-0.052424,0.043244,-0.010964,0.012554,-0.047057,0.001567,0.050788,0.013717,0.017090,0.034657,0.004238,-0.015847,0.029389,-0.005200,-0.013576,-0.057286,-0.016151,-0.048966,0.029973,-0.017670,0.023116,0.054592,-0.023336,0.031612,-0.036411,0.017106,-0.022705,-0.001708,0.058910,-0.004047,-0.045704,-0.036279,-0.029504,0.011506,0.049435,-0.062025,-0.003178,0.041854,-0.034540,0.021836,0.048177,0.058077,-0.028890,0.047214,-0.041436,0.019450,-0.062449,0.058614,0.045612,-0.060564,0.055688,-0.004700,0.034227,0.064114,0.036716,-0.010301,0.046936,0.053071,0.011806,-0.051091,0.053948,-0.058654,-0.006635,-0.002846,-0.055206,-0.055962,-0.032239,0.001675,-0.028585,-0.042177,-0.019441,-0.000758,0.039491,-0.058553,0.031442,-0.037696,-0.054806,0.038798,0.029642,-0.044586,-0.035191,0.016849,0.029657,0.009635,-0.037835,-0.013796,-0.012235,0.013503,-0.006763,0.044255,-0.018204,-0.036745,-0.037819,-0.060439,0.005589,-0.052402,0.042291,0.049490,-0.037097,-0.002939,0.022387,0.047832,0.050583,-0.016745,-0.043965,-0.001528,-0.026894,0.045213,-0.004014,0.002316,0.006585,-0.062404,-0.009242,0.008299,-0.045701,0.011849,0.054906,0.045048,-0.018168,0.008934,0.008427,0.011505,-0.010927,-0.041736,0.060661,0.058996,0.000094,0.004445,-0.010201,-0.033152,0.049860,-0.025652,-0.009552,-0.019701,-0.021693,0.019074,0.059541,-0.014839,0.029965,-0.000851,0.043402,0.014125,-0.057639,-0.017836,-0.028982,-0.038484,0.004133,0.047684,0.052570,0.047286,-0.007650,-0.055944,-0.057455,-0.028144,0.016553,0.022057,-0.024607,-0.015649,0.007614,-0.039826,-0.032559,-0.040184,0.015848,0.034643,-0.014592,-0.049959,-0.048851,-0.009967,-0.008055,0.007942,-0.047838,0.018378,0.002499,0.028262,0.046351,0.044385,0.039450,0.043543,0.058655,0.018740,0.045811,-0.047598,-0.038456,-0.035268,-0.007040,-0.029881,-0.047896,-0.017778,0.032257,0.019318,0.025226,0.059788,0.050432,-0.016783,0.019419,-0.037146,0.036076,-0.021678,0.035572,0.057884,-0.011750,-0.046500,0.011477,0.006916,0.005889,-0.031169,-0.038603,-0.041321,-0.042526,0.006647,0.054674,-0.018514,-0.000784,0.061490,-0.009779,0.051560,0.050559,-0.042281,0.010394,0.023820,0.032216,0.019182,0.004091,0.044015,-0.046581,0.064165,0.024611,0.006188,0.061998,-0.054065,-0.027195,-0.061710,0.052511,-0.026000,0.018691,-0.051974,-0.042106,0.021995,-0.019505,0.014482,0.050658,0.041864,0.058320,0.027823,-0.035742};
  parameter real W288[0:249] = {0.016854,0.019969,-0.031412,-0.044848,0.001505,-0.012312,-0.050963,-0.050840,0.016227,0.056823,-0.029484,-0.025295,0.043322,-0.009422,0.061835,-0.056835,0.020533,0.005949,0.053139,-0.031833,0.016215,0.009523,-0.026556,0.029083,0.018787,0.020308,-0.059129,0.001241,0.058808,0.059896,-0.001908,-0.045882,-0.053359,0.035989,-0.031155,0.051680,0.058942,0.042666,0.042909,-0.023070,-0.014030,-0.024244,-0.021119,-0.014353,0.049826,0.056182,-0.014805,0.057681,0.034769,0.000961,-0.002032,-0.003993,0.015085,-0.028797,0.023239,0.044153,0.046549,-0.023153,0.040656,-0.027692,-0.026256,-0.060655,0.049072,-0.043489,0.039576,0.017984,0.046754,0.045955,0.032006,0.008524,0.017964,0.049008,-0.060452,-0.011597,-0.015862,-0.058017,-0.003064,-0.008921,-0.034936,0.012757,0.027282,-0.010373,-0.004522,0.052066,0.029629,0.040955,-0.013660,-0.030875,0.009966,-0.000642,-0.019158,-0.007211,-0.018356,0.002235,0.012604,-0.068766,-0.005203,-0.031927,-0.037394,0.046345,0.035539,-0.043410,-0.032604,0.050272,-0.030244,-0.013620,0.040032,-0.008650,-0.007257,-0.047347,0.054168,0.020424,-0.032055,0.032480,-0.002911,-0.019218,-0.049703,0.059284,-0.021215,-0.057382,-0.068158,-0.032858,-0.023195,-0.021903,-0.049507,-0.051298,-0.026627,0.055710,-0.047666,0.027775,-0.004234,0.038187,-0.060710,0.019778,0.044193,-0.021399,-0.030340,0.061988,-0.006480,0.038513,-0.052649,-0.030110,0.017853,0.000408,-0.053467,-0.045869,0.022801,0.028166,-0.038116,-0.036258,-0.012527,0.027063,0.017352,0.034790,0.031941,-0.045434,-0.013872,-0.021919,-0.017138,0.008934,0.056815,0.057876,-0.028884,-0.031323,-0.000339,0.002862,0.032118,-0.007867,-0.037165,0.004180,-0.001998,-0.047661,-0.054937,0.003365,-0.034426,0.040259,0.031080,-0.050056,0.055938,0.052325,-0.060127,-0.014138,-0.008407,-0.001112,0.063297,-0.062866,-0.052511,-0.011252,0.039680,-0.030617,0.014878,-0.000146,0.001401,0.014831,-0.004746,-0.041746,0.037006,-0.053905,-0.034005,0.053039,0.035956,-0.059524,-0.065623,0.038158,0.051195,-0.013893,0.015711,0.028576,-0.034846,-0.050771,0.022903,-0.008457,0.062917,-0.041259,0.046245,-0.021902,-0.057198,0.054591,0.034143,0.049239,-0.001295,0.031276,0.039422,0.000679,0.061165,-0.060482,0.019888,0.038875,0.020370,-0.044633,-0.034102,-0.055595,0.008724,-0.007063,0.061180,-0.048664,-0.001078,0.048494,0.053333,-0.002312,-0.041477,-0.037948,0.058868,-0.027281,-0.010832,-0.009369,-0.007498,-0.045816,-0.045176,-0.044418};
  parameter real W289[0:249] = {0.025944,0.009014,0.013233,0.010426,0.030694,-0.014420,0.039631,-0.032801,-0.038974,-0.059481,-0.055317,-0.043654,0.054768,-0.051078,-0.023723,0.060443,0.029230,-0.022078,0.048713,-0.066066,0.020302,-0.036271,0.046169,-0.003756,0.014631,0.029743,0.050650,0.011885,-0.025025,-0.000197,-0.050380,0.004888,-0.010480,0.059251,0.006971,0.032506,-0.029552,0.017692,-0.016264,0.048252,0.049179,0.038682,0.048815,-0.052198,-0.037017,0.047273,0.024589,-0.026493,0.022306,0.050505,0.015983,-0.000696,-0.042325,0.053243,-0.056998,0.027074,-0.021175,0.046504,-0.031630,-0.033248,-0.004464,0.015814,-0.004358,-0.058752,0.001551,0.009163,-0.023192,0.058756,0.026571,-0.043541,-0.025033,-0.009730,0.036641,0.048382,0.040298,0.043662,-0.016212,0.016119,-0.022885,-0.010184,0.043062,-0.032802,0.051899,0.055949,-0.052480,-0.047483,-0.024437,0.024838,0.045322,0.016208,-0.006326,0.037357,0.012636,0.030603,0.049248,0.020708,0.000010,-0.037333,-0.062312,0.016351,-0.060886,-0.044282,-0.009853,-0.033406,-0.010807,0.032053,0.008757,0.037694,-0.012267,-0.036916,0.011580,0.033190,0.026193,0.023470,-0.012524,-0.042734,-0.018391,-0.026412,0.011502,0.022892,0.066608,0.054221,0.002981,0.058242,0.040544,-0.027408,-0.035866,0.035912,0.032791,0.006931,-0.020508,0.045653,0.050103,0.002052,-0.033411,0.023811,0.040969,0.032804,-0.017451,-0.015347,-0.025171,-0.018380,0.024826,-0.011274,0.015550,-0.019545,-0.005990,-0.046918,-0.037691,-0.013818,-0.005418,0.048131,-0.045657,0.000909,-0.047685,0.033374,0.058246,-0.004856,-0.015907,0.036210,-0.013899,0.016815,-0.022618,0.058502,0.042224,-0.029492,0.040536,-0.016057,-0.016738,-0.046817,-0.014739,0.037316,-0.049367,-0.032092,0.028484,0.041179,-0.014861,-0.043028,-0.055742,-0.031800,-0.037401,0.025867,0.008495,-0.059144,-0.017067,0.043042,-0.031682,-0.051653,-0.019485,0.054641,-0.039078,-0.035119,-0.040237,-0.014090,0.036052,0.053770,0.005914,0.030640,0.036655,-0.003187,-0.001853,-0.005842,0.029283,-0.025233,-0.018701,0.022902,-0.042771,-0.026342,-0.005068,0.007922,-0.059039,0.056605,-0.023569,-0.048041,-0.050960,-0.050213,-0.012920,0.006158,0.061077,0.030181,-0.062092,-0.008657,-0.013621,-0.019935,-0.011733,0.001948,0.060080,-0.033372,0.002351,-0.019663,-0.060329,-0.031301,-0.018186,0.027373,0.031195,0.024905,0.052675,0.051832,-0.019101,0.004150,-0.040798,0.032702,-0.044791,-0.059902,0.004825,0.017159,-0.031036,0.043765,0.028336,-0.059292};
  parameter real W290[0:249] = {-0.058412,0.017496,0.037076,0.033213,-0.058839,0.059126,0.027137,-0.025056,0.054505,0.015840,-0.022557,0.010311,-0.012341,-0.036391,0.035653,-0.036830,-0.008930,0.037896,-0.053338,0.020579,-0.057804,0.048431,0.028660,0.007555,-0.047263,-0.052552,-0.049909,0.003381,-0.010677,-0.061783,-0.006415,-0.004292,0.010823,0.030670,-0.027742,-0.041126,-0.024418,-0.036307,0.024300,-0.018992,-0.032894,-0.062701,-0.062311,-0.040811,0.026155,-0.051146,-0.006625,-0.066849,0.026700,-0.044596,-0.050659,-0.022126,0.012405,-0.056376,-0.057289,0.006021,0.050575,-0.017762,-0.000969,0.020847,0.001370,-0.049566,0.021592,0.006418,0.027402,-0.040422,-0.017772,-0.047449,0.061158,0.029543,0.015659,-0.002458,0.014673,-0.029413,0.003548,-0.022475,-0.016515,0.035062,0.060022,-0.025065,-0.026901,-0.052471,0.041558,-0.004977,0.022180,0.061159,-0.033160,0.038280,-0.026005,0.057465,-0.038979,-0.051477,0.064202,0.033734,-0.042565,-0.069504,0.054305,0.031750,-0.004642,-0.046357,-0.025196,0.017914,0.009367,0.038023,0.038665,-0.056196,-0.027525,-0.021216,0.022148,-0.009976,0.045296,0.025399,-0.055358,-0.043039,0.001137,0.048312,-0.037053,-0.035089,0.004961,-0.042528,-0.026331,0.022572,-0.019447,0.032845,-0.050923,-0.024747,0.030161,-0.041004,0.056636,0.009273,-0.019979,-0.004657,0.004123,0.038659,-0.001829,-0.011249,0.009192,-0.014158,-0.050551,-0.063777,0.019872,-0.000976,0.015373,0.035158,-0.000387,0.003389,-0.040379,-0.063772,-0.017058,-0.030418,0.040568,0.012750,-0.026605,0.022870,-0.066056,-0.026408,0.018551,-0.043872,0.047295,-0.030659,0.061867,-0.044965,0.047580,-0.001865,0.003727,0.021978,-0.031875,-0.034932,-0.033388,-0.035877,0.022770,0.009426,0.040753,0.057299,-0.016976,0.059100,-0.020266,-0.018940,-0.011653,-0.059923,0.016030,-0.053567,-0.026960,-0.024738,-0.015524,0.039194,-0.012313,-0.048984,-0.043899,0.024991,-0.060595,0.007047,-0.050637,-0.054419,0.052789,-0.012506,0.004582,-0.061251,-0.002868,0.005047,0.039959,-0.030633,-0.061781,-0.034897,-0.023112,0.054476,-0.043398,-0.002565,0.003991,0.021486,0.003077,0.049431,-0.013040,0.001942,0.036554,0.048643,0.026459,0.008609,-0.055992,0.023642,0.019303,-0.043383,-0.019703,0.028790,-0.005280,-0.053730,-0.018570,0.064084,-0.057733,0.057352,0.054556,-0.013791,0.014835,-0.062222,-0.010777,0.039700,-0.034665,0.030394,-0.020347,-0.057073,-0.017970,-0.023167,0.049857,-0.001534,-0.040408,-0.001411,-0.009821,0.017613,0.066984,0.019612};
  parameter real W291[0:249] = {0.043720,0.042981,-0.041710,0.058041,0.036469,0.029194,0.061612,-0.050475,0.043090,-0.009962,-0.065196,-0.019883,0.024130,0.059132,0.016850,-0.033771,-0.053289,0.040148,-0.008059,0.001425,-0.058128,-0.036994,-0.014097,0.027671,-0.041783,-0.011266,-0.022697,0.027326,-0.047926,0.057877,-0.027334,0.033370,0.059742,0.002468,-0.004609,0.047619,-0.002648,0.018939,0.027554,-0.031043,0.030117,-0.023993,0.015267,0.014518,0.035071,0.015079,0.061965,-0.024752,-0.009581,0.021460,0.011988,-0.002227,-0.012388,0.052084,0.057543,-0.032475,-0.042453,-0.031832,0.003575,0.025189,0.002944,-0.002905,0.056861,-0.002835,-0.010426,0.022774,0.020039,0.007558,0.044542,0.029702,-0.044717,0.030012,-0.029801,0.040982,-0.037835,0.033017,0.048203,-0.024704,0.058991,0.046511,0.005170,0.052225,0.046247,0.002966,0.046353,0.036379,-0.054832,0.047275,-0.021917,0.053157,-0.011685,-0.050350,0.053313,-0.058496,-0.018926,-0.049788,-0.020922,-0.009721,-0.040632,0.022631,-0.047735,0.049439,-0.029393,0.023165,0.053702,-0.043999,-0.064625,0.047108,-0.011479,0.007890,-0.019450,0.000971,0.037907,-0.053810,-0.035802,0.021845,0.002250,-0.052538,-0.051809,-0.052295,-0.036697,-0.056723,0.002553,-0.032848,-0.009382,0.028888,0.052453,0.054154,0.050905,0.024410,-0.048070,0.022798,-0.018552,-0.036417,-0.059456,-0.030692,0.048586,-0.047238,-0.057603,0.055890,0.025383,0.059478,0.054895,-0.019536,0.063175,0.004107,-0.049046,-0.045090,0.021929,0.061858,0.031043,0.000931,0.015781,-0.058340,0.056527,-0.016175,-0.061143,0.014026,0.003684,-0.022244,-0.039175,-0.023808,0.024044,-0.042450,0.016994,0.039428,0.057097,-0.011857,0.038953,0.000817,0.059183,-0.020913,0.001468,0.056463,-0.006879,-0.055776,-0.018740,0.026919,0.032453,0.048227,0.008205,-0.039971,0.036680,-0.059614,-0.033653,-0.037935,-0.050644,0.061593,-0.034606,0.019803,0.002729,-0.000342,-0.059145,0.003341,0.048972,0.024390,0.059569,-0.027366,-0.000491,0.020015,0.049664,0.014219,-0.054054,-0.019529,-0.021818,-0.060213,-0.053803,-0.043631,-0.036751,0.044845,0.056340,0.022632,0.015438,0.037418,0.038574,-0.031508,-0.057840,0.017696,-0.014864,0.053039,-0.039832,-0.008642,0.005102,0.061872,0.009686,0.025624,-0.034128,0.003384,0.059022,-0.048725,0.030241,0.021844,0.027689,-0.025866,0.013055,-0.038393,-0.028832,0.056560,0.028057,-0.031756,-0.037254,-0.012650,-0.042203,-0.054166,0.044286,0.048635,-0.027798,0.012607,-0.011850,0.044546};
  parameter real W292[0:249] = {0.026700,-0.020413,-0.045933,-0.013212,-0.019882,0.018298,0.043873,0.056142,-0.041146,0.067922,-0.009544,-0.041108,-0.056035,-0.036156,0.022804,-0.057670,-0.044840,0.049044,-0.025297,-0.020147,-0.025857,-0.035162,0.010548,0.024818,0.043312,-0.011980,0.018857,0.005660,-0.043003,-0.020098,0.046844,0.013045,0.017399,-0.002217,0.038282,-0.004307,0.006157,0.015174,0.039818,0.035075,-0.017817,-0.047485,0.050334,0.025516,-0.036932,-0.024646,0.017299,-0.046399,0.050854,0.045329,0.021239,0.054809,-0.039805,0.028675,0.031317,-0.016049,-0.031116,-0.049874,0.022245,-0.052654,0.038029,-0.018188,-0.058724,0.062518,-0.005475,-0.010836,0.012345,0.038879,0.028665,0.010818,-0.040535,-0.031495,-0.023648,-0.038920,-0.016293,-0.058749,0.027503,0.041084,-0.003873,-0.002188,0.017410,0.039605,-0.049764,0.037478,0.049470,0.036584,0.011722,-0.034559,0.014109,0.011321,-0.030529,-0.047232,-0.009919,0.022908,-0.037727,-0.061724,-0.006637,0.041994,0.042577,0.025884,-0.007127,0.025489,-0.006708,0.000832,-0.001864,-0.009951,-0.010134,0.063670,-0.012590,-0.035385,0.013814,0.012689,-0.039974,0.021343,0.045660,-0.038814,0.066992,-0.057873,0.028056,-0.019712,-0.049673,0.022611,-0.020172,-0.029227,0.012789,0.042357,-0.036334,0.002263,-0.049130,0.036114,0.048427,0.006904,0.020320,-0.055835,-0.057848,-0.001563,-0.020904,0.004842,-0.028550,0.067581,-0.055180,-0.006817,0.003960,0.014126,-0.000246,-0.028113,0.015249,0.032880,0.003172,-0.037860,0.017515,0.049994,0.019189,0.037616,-0.061488,-0.061123,0.029983,-0.004667,-0.002166,0.053537,0.036439,0.053453,0.048102,-0.050582,-0.046613,-0.016713,0.001847,-0.049254,0.039078,0.011483,-0.002533,-0.052234,0.033284,0.060354,-0.051572,0.022962,0.042357,0.048376,0.002012,-0.023364,-0.059235,0.007427,-0.040067,0.041139,-0.011093,-0.038183,0.002864,0.007769,-0.017012,0.028428,-0.032523,0.027366,0.003283,-0.044228,0.021056,-0.043914,0.015110,-0.041045,0.037386,0.032690,-0.025341,0.035384,-0.010993,0.018466,-0.016853,0.047053,0.012747,-0.003875,-0.058249,-0.019094,-0.051528,0.031904,-0.022150,-0.016515,0.042011,-0.047127,0.005414,-0.012889,0.008384,0.035240,0.007831,0.057152,-0.042250,0.055859,-0.011315,0.009972,0.057504,0.010892,-0.002337,-0.056479,-0.031306,-0.044956,0.014642,-0.010983,0.019795,0.010167,0.015493,0.047357,0.020096,-0.041214,-0.039446,0.034867,-0.009172,0.008829,-0.006080,0.036001,0.060282,-0.023292,0.037728,0.000404};
  parameter real W293[0:249] = {-0.040351,-0.062527,-0.046650,-0.006154,0.042541,-0.003422,-0.022130,0.036559,-0.054219,0.031220,0.021508,0.004347,-0.067116,0.057147,0.029173,0.042986,0.050523,0.048187,-0.041487,0.025289,-0.001482,-0.000748,-0.020609,0.049646,0.003094,0.024220,0.004085,0.014684,0.008390,0.063089,-0.041131,-0.027885,-0.019354,-0.011849,0.000842,-0.037272,0.006341,0.051420,-0.007980,0.044032,-0.025168,0.057640,0.031275,0.054706,-0.028340,-0.007125,-0.039390,-0.015433,-0.027767,0.029976,-0.060971,-0.051486,-0.019009,0.029998,0.017971,0.010661,0.047357,0.072279,0.042379,-0.045695,-0.007652,-0.007265,0.053692,-0.033314,0.019504,-0.057324,0.043473,0.001151,0.043716,-0.001289,-0.045969,-0.039720,0.026287,-0.007960,-0.008076,-0.021589,-0.010989,-0.047906,-0.016597,0.056281,0.030702,0.017075,0.009696,0.018695,0.002559,-0.039965,-0.016676,0.009589,0.038499,-0.014610,0.056287,-0.034401,0.011694,0.058932,0.040903,0.003440,0.018468,-0.017957,0.052235,-0.048233,0.032941,0.018937,0.063268,-0.006555,0.042518,0.025024,-0.042996,0.031147,-0.036141,0.041220,0.033333,-0.001355,0.047305,-0.022482,0.028562,0.005730,-0.019958,-0.000820,-0.020735,0.056664,-0.034793,-0.052350,0.061204,-0.029398,-0.014919,0.044033,-0.054149,0.006743,-0.044671,-0.042453,0.051121,0.005536,-0.060475,0.019033,0.053972,0.025276,-0.044217,0.022259,-0.009423,-0.023059,-0.041850,-0.013211,-0.057539,-0.048766,0.030444,-0.040096,-0.021081,-0.053677,-0.042629,-0.019815,-0.001717,0.053267,0.059336,-0.039671,-0.052298,-0.012461,0.055770,0.066410,0.032665,-0.036060,0.017915,-0.042199,0.039074,0.017292,0.040956,0.012217,0.009265,-0.046491,-0.016874,0.026167,-0.010120,-0.060935,0.047262,0.026753,0.066588,-0.047481,0.018860,-0.040314,-0.057966,0.063706,0.006975,-0.016193,0.039510,-0.007263,0.025454,0.030559,-0.014046,-0.024125,0.058207,0.040116,0.041165,-0.015518,0.014622,0.000316,-0.018721,0.035574,-0.030091,-0.064670,-0.043609,-0.013217,0.016632,0.027542,-0.023710,0.006040,-0.045599,-0.021906,0.013096,0.031755,0.044176,-0.042264,0.038624,-0.015855,0.042943,-0.051373,-0.025961,0.033956,0.041470,-0.001532,0.054132,0.061126,-0.066264,0.051835,0.029035,-0.038289,-0.025169,0.061882,0.063384,0.035541,-0.034522,-0.058959,-0.050274,0.061993,-0.029034,0.060053,-0.044977,-0.003823,-0.045241,-0.005805,0.030620,-0.047372,0.019950,-0.020113,0.024972,-0.017444,0.050477,-0.014921,0.059444,0.000059,-0.060295,-0.008531};
  parameter real W294[0:249] = {-0.007420,-0.006252,-0.043270,-0.011117,-0.052606,-0.033113,0.058920,0.003667,-0.052965,0.042135,0.034090,0.012584,0.010447,-0.042375,0.024390,0.020865,0.047257,-0.028119,-0.050765,-0.028121,-0.044967,-0.048142,-0.025379,-0.035474,0.017375,-0.012172,0.016983,-0.025604,0.011808,0.061576,0.018892,0.021946,-0.006005,0.007715,-0.023756,-0.057742,-0.053418,-0.055414,-0.018751,0.027881,-0.023977,0.028625,-0.061302,-0.050816,0.003369,0.002611,-0.050107,0.028352,0.000446,-0.023797,0.004075,0.040549,-0.025975,0.051865,0.008623,-0.041684,0.002709,0.047360,0.049297,0.058270,0.028842,0.010982,0.003578,-0.026893,-0.057123,0.004676,-0.040407,-0.009055,-0.020443,0.025458,-0.019306,-0.003789,-0.040501,-0.039178,-0.011756,0.026344,-0.052804,0.044442,-0.011240,0.056442,-0.050735,0.042740,0.007361,-0.025173,-0.006902,0.013812,0.007322,-0.021204,0.034947,-0.011742,-0.027012,0.047734,-0.007520,-0.064299,-0.047604,0.057264,-0.012544,0.027311,0.024116,0.024827,-0.005370,0.039717,0.018364,0.024325,-0.005676,0.009770,-0.069553,-0.024270,0.044240,-0.056998,0.031002,-0.059572,0.021062,0.047542,0.032526,-0.035328,-0.062069,-0.027356,-0.061593,-0.064908,0.023079,-0.034708,-0.004626,0.060034,-0.034754,-0.028958,0.035937,-0.000730,-0.033169,-0.005888,0.000741,-0.044722,-0.011957,0.054036,-0.027787,0.060927,0.055192,0.031713,0.029180,-0.039210,0.037126,-0.032400,0.011076,-0.032553,-0.034710,0.025777,0.037724,0.058233,0.003647,-0.065845,0.048275,-0.030390,0.002184,-0.041751,0.040996,0.012760,0.051108,-0.029335,0.020243,0.021220,-0.013247,0.009823,-0.014390,0.056899,-0.069376,-0.031210,-0.020312,0.041848,-0.003930,0.033387,-0.016455,0.052959,0.019696,0.052604,0.051334,0.035483,0.041447,-0.050776,0.012618,0.011315,-0.030754,0.060757,-0.027621,0.057883,-0.030312,0.008636,-0.035706,-0.049208,-0.003147,-0.035307,-0.052312,-0.053230,-0.010434,0.023047,0.007630,0.024087,0.039060,0.042141,0.057558,0.013289,-0.034289,0.058289,0.009194,0.027512,-0.019963,0.053253,0.048455,0.045037,0.030878,-0.060238,-0.067793,0.049519,-0.036464,-0.003719,0.043762,0.029910,0.024372,0.048350,0.009298,0.018933,0.043116,-0.017528,0.035589,-0.022624,-0.035117,0.016303,-0.023885,-0.013001,0.056458,-0.052973,0.000037,-0.006589,0.048930,0.023669,0.032297,-0.025038,-0.030216,-0.032881,-0.045260,0.067682,0.010779,-0.058782,0.030444,0.025058,0.015632,0.029472,0.001624,-0.008607,-0.024328,-0.048469};
  parameter real W295[0:249] = {-0.025566,0.048851,0.024702,0.011368,0.047379,-0.039688,-0.029462,0.052344,0.013889,-0.001290,0.041924,0.024602,-0.000790,0.011256,0.004030,-0.018398,0.024396,0.008883,0.016620,0.055482,-0.019490,0.018058,0.039153,-0.003442,-0.007910,0.032494,-0.060510,-0.043164,-0.046145,0.016332,0.010066,0.029677,0.041698,0.005726,-0.007361,-0.025678,0.008037,-0.045443,0.033861,0.002804,0.045831,-0.062196,-0.015683,-0.064345,-0.062551,0.033882,-0.024601,0.053549,0.053167,0.033793,0.052907,-0.058291,-0.004198,0.035954,-0.030629,-0.074964,0.066355,0.045326,-0.024048,0.008666,0.056751,0.017130,0.051245,0.017900,0.032666,0.035744,-0.027221,-0.053852,0.025703,0.019251,0.015177,-0.047848,-0.033859,-0.018172,-0.035029,-0.015825,-0.056804,0.059045,0.044901,-0.000566,0.029980,-0.032633,-0.000876,-0.021469,-0.038560,0.028589,-0.009270,0.045020,0.039249,-0.033881,0.011451,-0.017522,-0.045679,-0.029994,-0.059909,-0.037672,0.067182,-0.039958,-0.033072,0.016174,0.037278,-0.064704,0.009891,0.038371,0.045556,0.038065,-0.039049,-0.061035,-0.036322,0.043831,0.014698,0.058292,0.034699,-0.059799,0.042389,-0.033640,-0.050568,-0.046175,-0.043477,0.034778,0.023614,0.022173,0.007466,0.049470,-0.036042,0.039985,-0.019361,0.041900,-0.002330,-0.024776,-0.035589,-0.038312,0.061493,-0.042348,-0.006731,-0.038450,0.058126,-0.016487,0.035088,-0.004332,0.047295,-0.026386,-0.056435,0.037234,0.049800,0.048895,-0.008483,0.048879,0.045717,0.055112,-0.041321,0.012554,0.040103,0.011198,0.014130,0.044148,0.025899,-0.023411,-0.051006,0.044128,-0.062725,0.029284,-0.016032,0.064525,0.052606,-0.042915,0.039492,0.015909,-0.018639,0.026021,-0.039345,0.013747,0.046052,0.014879,-0.046489,0.004511,-0.027871,0.006644,-0.060630,-0.033233,0.012501,0.041297,0.005275,-0.071485,-0.050453,-0.003375,0.063012,0.036207,-0.042781,0.020187,-0.004227,-0.071687,-0.014865,0.045664,-0.005368,-0.023231,-0.050284,-0.016365,-0.056487,-0.033906,-0.004246,0.012512,-0.027378,0.023497,0.044894,0.011408,-0.015022,0.021615,-0.054993,-0.061569,-0.028857,0.003203,-0.022126,-0.029819,0.064208,0.008897,0.034342,0.031236,0.060354,-0.058823,0.043349,-0.055245,-0.011988,-0.036577,-0.003356,-0.032659,-0.063039,0.037839,-0.005696,-0.006358,0.028835,0.036525,0.047448,0.041840,0.067275,-0.035039,0.008120,-0.050476,-0.001980,-0.061473,-0.006676,0.040799,0.054586,0.023034,0.015739,-0.001214,0.060357,-0.001865,-0.034855,-0.016329};
  parameter real W296[0:249] = {0.001407,-0.000370,0.040591,0.043304,-0.028972,0.017638,0.059414,-0.056057,-0.015806,0.018047,0.010744,-0.001109,-0.021160,0.008830,0.044439,0.001967,0.014573,-0.028898,0.061099,-0.015689,0.056326,0.051479,-0.061921,0.027957,-0.005832,-0.001946,0.055986,0.061543,-0.016913,0.001108,0.042771,0.048908,0.066823,0.031209,0.051782,-0.001951,0.018292,0.036610,0.021266,0.012313,0.053069,-0.007743,0.026667,0.017765,0.054317,0.019581,-0.051374,0.029494,-0.010524,-0.014766,-0.000548,-0.000795,0.034716,0.048165,-0.018272,0.028930,0.057623,-0.036144,0.064038,0.015339,-0.035302,-0.018723,-0.046202,0.048187,-0.033999,0.000682,-0.032536,-0.003064,-0.016668,0.046079,0.020838,0.049250,-0.031380,-0.041520,0.010491,-0.024133,0.047530,-0.028256,-0.001417,-0.049192,0.053389,-0.015553,-0.015394,0.058044,-0.037528,0.046001,-0.015242,-0.043509,0.006637,-0.048873,-0.029787,-0.006426,-0.046958,-0.011818,0.051081,0.024424,-0.041693,0.040701,0.046128,-0.014286,-0.004190,0.054399,-0.038400,0.022297,0.028639,0.009777,-0.063560,0.022604,0.021889,-0.025102,-0.028364,-0.003266,-0.010678,0.067214,0.021635,0.015882,0.009827,-0.061530,-0.053307,0.044030,0.073172,0.001017,0.074878,-0.000530,0.071282,-0.002589,-0.061562,-0.064250,0.026746,0.021739,-0.022662,-0.057462,0.045726,-0.012770,-0.040997,-0.036608,0.011938,0.056485,0.001814,-0.022570,-0.040021,-0.054750,0.042582,-0.040892,0.036778,0.032019,-0.059596,0.011869,0.058718,-0.066873,0.061131,0.005318,0.001628,-0.048169,0.011077,-0.009085,-0.017966,0.026723,0.055379,-0.010420,0.032210,0.001017,-0.051139,-0.024361,-0.031802,0.003722,-0.061031,0.060308,0.025665,-0.024340,0.046113,-0.006109,0.028919,0.014572,0.039644,0.003443,-0.024444,-0.050305,0.033533,0.028295,-0.008331,0.017949,-0.049255,-0.050514,0.033309,0.010712,0.041951,0.031700,-0.038794,-0.014885,-0.020438,-0.008531,-0.039018,-0.026477,0.071658,0.035310,0.062487,-0.010913,0.010171,0.015844,-0.018177,0.031862,-0.052346,-0.034779,-0.031799,0.052376,0.012391,0.031704,0.016938,0.056068,-0.009575,0.061687,-0.062361,0.001918,-0.040946,0.013864,-0.043859,0.029688,-0.010929,0.021672,0.018358,0.016036,0.057366,0.026277,-0.010434,0.053233,0.048711,0.045622,-0.037115,-0.010120,0.055085,-0.000413,-0.059489,-0.038898,0.060402,-0.040666,0.006008,0.049272,-0.013044,-0.012397,0.054931,0.048304,0.026824,0.037223,0.050205,0.045053,0.043090,-0.015226,0.034297,-0.031797};
  parameter real W297[0:249] = {-0.012275,-0.054739,0.006612,-0.042649,-0.069147,-0.032596,0.013383,-0.056547,0.013797,0.050301,0.003180,-0.033999,0.061667,-0.002192,-0.010410,-0.038576,-0.016671,0.032043,0.034032,-0.022882,0.031498,0.005370,-0.035969,0.051943,-0.043127,-0.050178,-0.001665,-0.019364,0.047609,0.058077,0.060985,-0.044961,0.047101,0.040373,-0.004252,0.039770,-0.001512,0.018624,0.036859,0.018941,-0.035407,-0.020485,0.049986,-0.049623,0.042928,-0.030812,0.058056,0.006459,0.029893,0.056791,0.059833,-0.057915,-0.014020,-0.025091,0.042524,0.032658,0.046462,-0.060907,-0.026889,0.061990,-0.009253,-0.015959,0.044190,-0.054040,0.047248,-0.013942,0.019967,0.006828,-0.016626,-0.038109,-0.043807,-0.002769,-0.005382,0.009515,0.006549,0.017251,0.029795,-0.019744,-0.026462,0.042457,-0.053982,-0.062398,0.055812,0.017313,0.003052,0.001816,0.020737,0.061571,-0.058693,-0.041727,-0.028029,0.040107,-0.012210,0.026699,0.028388,0.041730,-0.011837,-0.057197,0.007626,0.010668,-0.039675,-0.030828,-0.023502,0.031953,0.048890,-0.034865,-0.012243,-0.004773,0.026639,-0.016780,0.008754,-0.006790,-0.048569,-0.013344,-0.042564,0.056198,0.020347,0.021456,0.059132,-0.046095,0.009639,-0.047615,-0.010234,0.010195,0.026721,-0.002822,0.008297,0.053379,-0.065397,-0.035668,0.009341,-0.012235,0.062583,0.044126,0.001919,0.013916,0.014242,-0.040697,-0.034281,-0.022688,0.044571,0.033481,0.004228,0.025025,-0.038020,-0.025911,-0.006172,0.034091,-0.003731,-0.045445,-0.027539,0.015771,-0.046929,0.006761,-0.008770,-0.003125,0.018009,-0.051686,-0.026945,-0.037466,0.038263,-0.018978,0.009170,0.019127,0.010402,-0.013814,0.054952,-0.050817,0.001499,-0.037571,-0.019391,-0.036524,-0.028007,0.050848,0.000181,-0.009313,0.038278,0.059944,-0.013802,0.017887,0.008432,0.015849,-0.027992,-0.022978,0.055593,0.005087,-0.026855,0.029515,0.026276,-0.001795,-0.021115,0.018502,0.052655,-0.043918,0.049426,-0.022233,-0.042018,0.027219,0.035199,0.000735,0.002622,0.007315,-0.034057,0.050006,-0.020638,-0.013411,0.031512,-0.033317,-0.052700,-0.011790,0.025436,-0.026347,0.024894,-0.044919,0.000843,-0.046187,-0.015756,0.019377,0.033156,-0.024638,-0.037789,-0.040061,-0.025759,-0.002773,0.048393,-0.024611,-0.016768,-0.061984,-0.055222,0.062283,0.051266,-0.034931,-0.031117,-0.046690,0.057012,-0.059759,0.047726,-0.050637,-0.033685,0.052617,-0.023520,0.023690,0.031505,0.034540,0.059831,-0.019906,-0.013431,-0.034707,0.049077,0.048871};
  parameter real W298[0:249] = {-0.073066,-0.062210,-0.061985,0.050712,0.068063,-0.043952,0.012363,0.010206,-0.001869,-0.049917,0.024123,-0.066971,0.045626,0.032812,0.022711,-0.069450,-0.043909,-0.053427,0.071075,-0.020982,-0.037745,-0.008651,-0.008540,-0.054960,0.032495,0.042297,0.008042,-0.026406,-0.002730,0.046299,0.022527,0.032915,0.004075,0.042119,0.086437,-0.045140,0.004263,-0.032133,-0.013262,-0.041622,-0.010788,0.025595,0.038025,-0.043000,0.030404,-0.009905,0.035547,0.008501,-0.006379,0.013439,0.051957,-0.031115,0.044255,0.021358,-0.066501,0.038423,0.028224,0.071410,0.022455,0.004748,0.030185,-0.051636,0.011181,-0.006384,-0.042643,-0.038129,0.049376,0.022264,-0.077648,0.051116,-0.062981,0.026213,0.061557,-0.018916,-0.068887,-0.033363,0.018858,-0.034939,0.047389,0.028810,0.026805,-0.047130,-0.020009,0.043199,0.055412,-0.006123,-0.060579,0.042637,-0.008549,0.005979,0.046855,0.006262,0.048836,0.035966,0.013732,0.063281,0.003358,0.023387,-0.024594,0.009206,0.054896,0.059194,-0.036367,-0.006167,-0.031905,-0.032937,0.003210,-0.024403,-0.033078,0.052673,-0.050186,-0.011252,-0.017581,-0.049209,-0.036336,0.006192,-0.040565,0.056942,-0.025815,0.040134,0.044452,-0.053637,0.060598,-0.033009,-0.022254,0.025396,0.053767,0.007484,-0.000357,-0.031398,0.007395,0.010112,-0.045053,0.061492,0.064211,0.047064,0.013977,0.022457,0.001354,0.039320,-0.033516,-0.022511,-0.031739,-0.030266,-0.018634,0.044882,-0.058705,0.054920,0.057155,-0.013479,-0.021555,0.050364,0.083826,-0.050017,-0.018221,0.052806,0.025783,0.004380,0.026959,-0.073813,-0.018371,-0.038454,0.078342,0.047518,-0.025517,-0.010547,-0.010512,0.062682,-0.049801,0.028220,0.029312,-0.003534,0.011113,-0.051985,-0.007741,-0.035616,-0.026007,0.018606,-0.014947,0.067556,0.049313,0.014975,-0.005675,0.020662,0.029450,-0.013430,0.004625,-0.054160,0.033590,0.072900,0.062375,-0.018844,0.032037,0.055284,0.024516,0.007207,-0.050138,-0.048853,0.016152,0.017574,-0.056534,-0.021724,0.021442,-0.001899,0.010968,0.051971,0.032184,0.048293,-0.051512,0.052146,0.054877,-0.016268,0.017151,0.019565,0.055049,0.049209,-0.002465,-0.018510,0.014227,0.041412,0.046978,-0.015884,0.020614,-0.041542,-0.011812,0.064076,-0.018155,-0.062019,-0.019017,-0.033844,-0.039829,-0.048107,-0.070420,-0.041365,0.007154,0.017830,0.032447,-0.058932,0.014935,0.010691,-0.048988,-0.062233,-0.050818,0.003300,0.038465,0.018736,-0.034095,0.024712,-0.030144,0.009492};
  parameter real W299[0:249] = {-0.031773,-0.053965,-0.005211,-0.022280,-0.037250,0.003290,0.006422,-0.029536,-0.057918,0.032560,-0.023210,0.056252,0.060502,-0.007307,0.000163,0.049826,0.025244,0.019247,-0.013795,-0.063429,0.052627,-0.004903,0.016520,0.041434,-0.004090,0.017488,0.023977,-0.036367,0.023918,0.048730,0.039712,-0.027527,0.022946,-0.014592,-0.029379,-0.056278,0.043661,-0.055581,-0.028149,0.027825,-0.030720,-0.014646,-0.054222,0.002554,0.045502,-0.000928,0.001337,-0.043731,-0.033889,-0.047444,-0.017431,0.033486,-0.013259,-0.003540,0.052669,0.064454,-0.041406,0.024111,0.009488,-0.032334,-0.034981,0.021712,0.014534,0.020950,0.033361,0.039604,-0.008454,-0.015894,-0.055933,0.020243,-0.052031,-0.063741,-0.017416,-0.046456,-0.043597,-0.002169,0.040221,0.036678,0.023881,0.035856,0.026891,-0.001641,-0.058711,0.066945,0.033982,-0.034197,-0.006960,0.041119,-0.056269,0.000843,-0.047923,0.039279,0.049579,-0.051816,-0.015084,-0.032229,-0.049540,0.008661,-0.005814,-0.049715,0.036369,-0.012984,-0.042867,0.051395,0.053258,0.050245,0.012622,0.004787,0.029008,0.008590,0.013440,0.044455,-0.018151,-0.061980,-0.029910,-0.037222,0.043005,0.060486,-0.049787,-0.013064,0.034579,-0.055582,-0.024031,-0.052593,0.012740,0.011603,0.053610,-0.041454,-0.048748,-0.063918,0.064664,-0.004967,0.061066,0.043695,0.051972,0.031588,0.008718,-0.007114,0.052018,0.033378,-0.009989,0.059755,0.032914,-0.010027,0.025747,-0.064905,-0.044906,0.012257,-0.009662,-0.020691,0.036804,-0.008481,-0.061257,-0.047674,-0.007033,0.059609,0.024477,-0.003408,-0.019768,0.064741,-0.031209,-0.009417,0.050283,-0.024287,0.001259,0.021751,0.040051,0.035800,-0.025984,-0.045127,0.034432,0.029130,-0.060734,-0.031819,0.039850,0.029232,-0.002082,0.026600,0.054372,0.005106,-0.030657,-0.027075,-0.040160,0.058709,-0.053144,0.031613,-0.030203,-0.025619,0.048527,0.051569,-0.045098,0.048718,0.034185,0.000056,0.004477,-0.056894,-0.032623,-0.051426,0.019787,0.041372,0.012699,0.064288,-0.008259,-0.048308,0.026998,-0.009584,0.037182,0.053103,0.058187,0.031763,-0.041263,-0.013739,0.002837,0.041183,0.037461,0.046350,0.005249,-0.012798,0.000294,-0.032251,-0.012731,-0.036559,0.030368,0.040983,0.025576,-0.007384,-0.029033,-0.016455,0.029407,0.037721,-0.028304,-0.028262,0.055595,-0.031656,-0.051995,-0.052955,0.009364,-0.020610,-0.066130,-0.010444,-0.041732,-0.040215,-0.031052,-0.009280,-0.050512,0.034906,0.045462,-0.011678,-0.026616,-0.050326};
  parameter real W2100[0:249] = {0.026225,0.025415,-0.046780,-0.008316,-0.038597,-0.003110,0.049886,0.040576,-0.003208,0.046204,-0.009202,0.002914,-0.003895,0.042487,-0.005524,0.045456,0.044917,-0.056283,0.000929,-0.029598,0.016114,0.056473,0.026436,-0.038308,-0.049736,0.015443,0.007322,-0.017330,0.036359,0.059781,-0.018401,0.011786,0.024452,-0.007833,0.012327,0.032449,-0.020576,0.025095,0.047912,-0.025748,0.014506,-0.031627,-0.013670,0.046534,-0.049933,-0.010095,0.001993,-0.009578,-0.037436,-0.010805,0.029684,-0.016937,0.052516,0.048903,0.057132,-0.054310,-0.045629,0.022527,-0.053151,-0.063621,0.032784,-0.018315,0.004080,-0.033344,-0.044238,-0.035252,0.055000,-0.043043,0.020684,-0.013019,-0.019539,0.035167,0.054323,0.029460,-0.034141,0.019608,0.025430,0.003616,0.017342,0.028865,-0.039373,-0.049764,-0.054399,-0.032064,-0.006332,-0.025630,-0.051263,0.029152,0.001314,0.028160,0.055109,0.054101,0.003131,-0.008879,-0.031576,0.059020,-0.017270,-0.030951,0.054931,0.046231,-0.045911,0.050757,-0.041237,-0.036028,0.010862,-0.017537,0.021060,-0.007789,-0.002456,0.031285,0.035223,-0.048418,-0.048693,-0.031357,-0.016844,-0.046571,0.014741,0.001812,0.021395,-0.045000,-0.006945,-0.003089,-0.016833,0.013710,-0.002805,-0.060915,0.039096,0.053874,0.025436,0.033820,-0.038503,-0.019853,-0.037940,0.052679,-0.005603,-0.003188,0.021223,0.026265,0.030967,-0.020566,0.038397,-0.008552,-0.044055,-0.021685,0.047129,-0.050124,-0.028438,-0.011585,-0.058188,-0.018361,-0.020739,0.033108,0.006801,-0.007310,-0.050288,0.010449,-0.011519,-0.011036,0.042832,0.038867,0.023141,-0.027994,0.009699,-0.052376,0.022148,0.015503,0.049273,0.002594,-0.059061,0.033440,0.057876,-0.047758,-0.056749,0.059423,0.056634,-0.033587,0.039900,-0.038652,0.005130,0.012813,-0.060505,-0.057392,0.045653,0.051316,0.008408,0.019148,0.025113,0.049393,0.021584,-0.017235,-0.007451,-0.033480,0.010322,-0.053747,-0.048272,0.002269,-0.041010,0.052349,-0.002019,-0.012923,0.030981,-0.011404,-0.041714,-0.052540,-0.058926,-0.028957,0.017852,0.008385,-0.013802,-0.060476,-0.018801,-0.055495,0.059410,0.047431,0.050629,0.018063,0.044196,0.020527,-0.036856,0.041535,-0.006883,0.006869,-0.014640,-0.044582,0.027398,-0.015687,-0.052886,-0.046551,0.024417,-0.039302,0.061228,0.021168,0.014725,-0.022993,-0.022566,-0.047754,-0.011067,0.008509,0.019829,-0.033329,0.029684,0.016532,-0.016476,0.043766,-0.019231,-0.000247,-0.043335,0.009060,0.028975,0.055380};
  parameter real W2101[0:249] = {0.034288,0.050070,0.006396,-0.003258,0.039542,-0.058188,0.042703,0.049207,0.027737,-0.001742,-0.011952,-0.038130,-0.031337,-0.027587,0.050465,0.030253,-0.028425,0.053273,-0.046224,-0.020984,0.063192,-0.052856,-0.015574,-0.007724,0.033575,0.010770,0.045470,0.018840,-0.019919,-0.017309,-0.005144,0.008703,-0.008244,0.043322,-0.044146,0.053642,0.031333,0.036885,0.035367,0.008901,0.004358,-0.028962,-0.027038,0.036803,0.034433,-0.026341,-0.005309,-0.002773,0.035904,0.055816,0.007519,-0.018602,0.016368,0.048894,-0.057308,-0.012861,0.050989,0.019944,0.011274,0.039584,0.042632,-0.066705,0.061844,0.032414,0.015078,0.031383,-0.055812,-0.040311,0.008435,-0.009020,-0.007439,0.029606,0.033524,0.002157,-0.071290,0.053625,0.014890,0.042592,0.047966,0.007225,-0.013965,-0.019622,0.038015,-0.009894,0.043242,-0.052493,0.049481,-0.038146,-0.056267,0.003687,-0.007301,-0.024078,-0.057658,0.003546,-0.040096,0.031558,0.009874,0.002063,-0.039352,-0.045493,0.005514,-0.038155,0.018777,-0.011237,-0.057698,-0.034879,0.042500,0.028517,0.006766,-0.047042,-0.004907,0.010534,0.044849,0.030653,0.029896,0.008410,-0.056526,0.033728,0.026943,-0.012438,-0.002675,-0.060186,0.044405,-0.055291,0.026188,-0.045321,0.038706,0.045549,-0.004386,-0.003661,-0.043265,0.024920,-0.007909,-0.048398,-0.020896,0.049821,-0.048414,0.036168,-0.011985,0.009623,0.047591,-0.036666,-0.060524,-0.015140,0.013906,0.045421,-0.056871,-0.011487,0.018802,0.022695,-0.060318,0.025308,-0.017368,0.020491,0.038367,-0.004833,-0.027368,0.010917,0.000176,0.025143,0.041840,-0.020848,0.035166,-0.044858,0.040428,0.051156,0.059516,-0.014251,-0.034468,0.038307,-0.063778,0.014554,0.009526,-0.007961,0.061775,-0.012941,0.047777,0.000771,0.033553,-0.025756,0.058866,0.004390,0.022317,0.007238,0.039952,-0.040729,0.013361,0.038734,-0.045540,0.020279,0.055472,0.037731,-0.010428,-0.037130,-0.015976,0.024681,-0.038658,-0.020479,-0.003578,0.054879,-0.034853,-0.004421,0.034187,-0.013285,0.006070,0.017947,0.019226,0.033062,0.022252,-0.021312,-0.038209,-0.050319,0.023242,0.036958,-0.006574,0.042783,0.061336,-0.027714,0.065516,-0.029861,-0.032835,-0.036527,-0.045811,-0.015336,-0.047000,-0.011349,-0.002110,0.029693,0.006656,0.014589,-0.066168,0.040967,-0.059215,-0.023072,0.050457,0.042768,0.013661,-0.062568,-0.031036,0.053039,-0.010532,-0.035631,-0.038613,-0.006730,0.031709,-0.040572,0.063682,-0.015293,0.005781,-0.055300};
  parameter real W2102[0:249] = {0.004161,0.031482,0.056653,-0.026713,0.028387,-0.024775,-0.025828,0.003345,0.054747,-0.053798,0.063779,0.056302,0.013492,-0.035117,0.034284,-0.056457,-0.035614,-0.051145,-0.042947,-0.024144,0.049061,0.018444,-0.060612,-0.026356,0.011026,0.045464,-0.004402,0.032641,-0.046659,0.017996,-0.048728,0.008888,0.045639,0.039899,-0.014179,0.055679,0.027497,0.026361,-0.018040,-0.031528,-0.023034,0.011229,-0.044133,0.024579,0.016058,0.020683,-0.053228,0.058249,0.064356,0.047888,-0.046400,0.051455,-0.028715,-0.052567,-0.020006,0.001473,-0.025163,0.044588,-0.053271,0.018899,0.058350,-0.063885,0.060848,-0.046005,-0.020947,0.056524,-0.053272,0.051143,0.006869,0.047434,0.024637,0.059639,0.006772,-0.050073,0.040631,0.034667,-0.052027,-0.014678,0.035653,-0.008381,-0.025999,0.015161,0.044497,0.063295,-0.011367,0.056003,0.027514,-0.047031,0.061717,0.000297,-0.016685,-0.013159,-0.048446,-0.015778,-0.063929,-0.014593,0.017554,-0.013293,-0.004639,-0.033879,-0.005307,-0.052218,-0.053188,-0.031753,0.002615,-0.052962,-0.037920,0.003996,0.004329,0.035765,0.043273,0.064445,-0.056025,0.046632,-0.038498,0.062764,0.059963,-0.016034,0.012788,0.001847,0.056776,-0.041362,-0.010628,0.060549,0.018440,0.039545,-0.053395,0.020590,-0.021683,0.042845,-0.065700,0.033177,-0.006918,-0.039164,0.028134,-0.046835,0.055585,0.039631,0.009917,-0.041195,0.036425,-0.003093,-0.022527,-0.017207,-0.053072,-0.041537,0.027755,0.002751,0.059018,0.052563,-0.011509,0.053762,0.067478,-0.047289,0.031292,-0.040652,-0.053499,0.028897,0.063278,-0.052703,0.034256,0.044673,0.035481,0.037675,-0.033266,0.038113,0.038707,0.031546,-0.023993,-0.033332,-0.057994,0.028264,0.015326,-0.008895,0.051715,-0.039131,-0.042009,0.038802,-0.019500,-0.031895,0.039924,0.049396,-0.004645,-0.009494,-0.022833,0.028464,0.036815,0.052801,0.052517,0.031030,-0.036456,0.026272,0.054395,-0.013850,-0.044805,0.051777,-0.061147,-0.006887,-0.046798,-0.008502,0.008048,0.017017,-0.007704,0.040450,0.040554,0.051487,0.009743,-0.035383,0.061019,0.048370,0.026579,-0.010228,0.045515,-0.017699,-0.001747,0.025257,0.038293,-0.058654,0.052403,-0.061052,0.011198,0.056033,0.024463,-0.023335,0.006432,-0.059625,-0.056598,0.035185,0.062844,-0.023675,0.043325,0.053845,0.017890,0.028811,-0.062988,-0.059264,0.007769,0.052717,-0.054340,-0.060541,0.038277,-0.022991,0.051895,-0.033074,-0.032850,0.004218,-0.053047,-0.059458,0.014412,0.048163};
  parameter real W2103[0:249] = {0.045656,0.062765,-0.013627,0.018541,-0.042287,-0.056527,0.057844,0.000829,0.026033,-0.042581,-0.047195,-0.012931,-0.030438,-0.042734,-0.023885,0.015397,0.029158,0.065704,-0.014120,-0.002603,-0.011286,0.042946,0.016063,0.033856,0.049197,-0.033661,0.048650,-0.045212,-0.048288,-0.020579,-0.055545,0.033527,-0.019844,0.021394,-0.052923,0.043215,-0.054296,-0.050448,0.042075,-0.020179,-0.035894,-0.024637,-0.026035,-0.051995,-0.051835,0.058287,0.029552,-0.036671,-0.062169,0.028391,-0.022878,0.023899,-0.030066,-0.009339,0.051097,0.025398,-0.051228,-0.012841,0.055126,0.035661,-0.015263,0.027286,0.044030,0.027358,-0.050192,-0.064471,0.022167,0.054245,0.046920,-0.054256,0.017205,-0.034099,0.007776,-0.029160,-0.030444,-0.053710,-0.019031,-0.006768,0.022578,0.062584,0.001579,-0.003936,-0.022370,-0.031486,-0.019857,-0.007707,-0.056047,-0.026285,0.052357,-0.067491,-0.024848,-0.000974,0.008531,-0.050875,-0.058529,0.000441,-0.006924,0.058905,-0.024822,-0.021759,0.000244,0.013249,-0.053493,0.005861,-0.014203,-0.027915,-0.045972,-0.026524,-0.048101,0.023717,0.052812,0.016332,-0.047816,0.023956,-0.035026,0.009023,-0.053486,0.005689,0.053854,-0.034145,-0.037239,0.020944,-0.027306,-0.029742,-0.031311,-0.023718,-0.004639,0.004436,-0.058610,-0.028633,0.066070,-0.005375,0.053185,0.042907,0.020233,-0.042092,0.050135,0.027707,-0.005211,0.011842,0.046290,-0.058227,0.046870,0.003791,-0.052164,0.045485,0.042219,0.014692,-0.029564,-0.055084,0.060517,0.004496,0.026701,0.038038,-0.038429,-0.028360,-0.042388,0.040753,0.005464,-0.054309,0.030996,0.055199,-0.001718,0.051591,0.034734,0.004533,-0.029655,-0.000757,0.044100,-0.012565,0.052124,-0.017339,-0.051730,-0.035229,-0.027036,0.008390,0.047447,-0.008449,0.059631,-0.045285,-0.015350,-0.045533,-0.030702,-0.037232,0.041406,0.050425,0.021946,0.015364,-0.052359,-0.032971,-0.058427,0.061057,-0.050921,0.039741,-0.050356,0.064513,0.015055,0.034576,-0.035749,-0.007111,-0.014994,-0.010620,0.006824,0.009256,-0.010520,0.019298,-0.023117,0.043264,-0.032389,0.022415,0.032793,-0.033077,-0.048291,0.009465,0.027297,0.005743,0.064918,0.005299,0.032379,-0.029453,-0.010110,0.007348,0.011860,0.002095,-0.063965,0.034758,-0.061594,0.041296,0.059235,-0.051452,-0.025870,-0.013727,0.033999,0.009489,-0.044742,0.000354,-0.029240,-0.041936,-0.011017,0.034550,0.035701,0.048492,0.002251,-0.042246,0.014987,-0.030659,0.038140,0.047852,0.025089,0.001895};
  parameter real W2104[0:249] = {0.013695,-0.057676,0.034176,0.027831,0.020708,-0.006275,0.042974,0.048571,-0.041324,-0.038256,-0.057821,0.013030,0.063791,0.044350,-0.006027,-0.000637,-0.058992,-0.036229,-0.014899,0.027957,0.033406,-0.030296,0.053975,0.061671,-0.014211,-0.012327,0.040761,0.007819,0.053266,0.056437,0.024361,0.006134,0.004745,0.018840,0.069131,0.055635,0.014564,-0.044619,0.057229,-0.025289,0.011659,0.001834,0.039623,0.062246,-0.018589,-0.041930,-0.015360,0.022698,-0.059940,0.060767,0.033409,0.011850,-0.038626,-0.027662,-0.019963,0.011610,-0.017969,0.009837,0.032280,0.050045,0.032153,-0.037754,-0.052986,0.049924,0.034530,-0.043876,-0.041850,0.018984,-0.032171,0.016430,0.034171,-0.005569,-0.007786,0.040820,-0.043780,-0.019213,-0.048945,-0.013058,-0.031433,-0.042355,-0.053088,0.039055,-0.020605,-0.032695,-0.015635,0.016406,-0.031012,-0.065096,0.033071,-0.042129,0.059426,0.014624,0.043234,-0.003125,0.008322,0.045004,-0.007725,0.023251,0.040881,0.005826,-0.046515,0.007349,0.026214,0.056963,0.019274,-0.047783,-0.029685,-0.054328,-0.001143,-0.033303,-0.028978,-0.064762,0.011888,0.039462,-0.045019,-0.015337,-0.043781,-0.062667,-0.042848,0.000911,-0.023026,0.004137,0.053976,0.025314,0.027854,0.059258,0.022818,-0.034333,0.017423,-0.036886,-0.053002,-0.043509,0.012191,-0.021265,-0.043347,-0.059495,0.036825,-0.006932,0.045963,0.046313,-0.043643,-0.049781,0.010596,-0.025468,0.003346,0.008535,-0.017134,0.020180,0.055387,0.007173,-0.046901,-0.047299,-0.017619,-0.071718,0.022110,0.038919,-0.066332,0.015009,-0.036030,-0.044471,0.034463,-0.019223,-0.019115,-0.032434,-0.065623,0.017890,-0.034022,0.056814,-0.044531,-0.009369,-0.034537,-0.011730,-0.039751,-0.059304,0.002568,0.041011,-0.042704,-0.035719,0.046228,-0.018160,0.004393,0.007692,0.011952,-0.001388,0.044356,-0.048479,-0.012820,-0.032545,0.050997,0.006620,-0.006519,-0.053021,0.017381,-0.000753,-0.054041,0.010367,-0.049329,-0.055504,-0.003483,0.065580,-0.010928,-0.037958,-0.040153,0.029033,-0.056940,0.003351,0.035313,0.000467,0.005544,0.003095,-0.070524,0.009185,-0.061728,-0.035196,-0.008724,0.040800,-0.024986,-0.047746,0.047044,-0.029158,0.017898,0.038223,-0.008942,-0.055880,-0.021262,0.063672,-0.042226,0.019692,0.025241,0.038659,0.012200,0.026271,0.042528,0.028473,0.043828,-0.025126,0.048163,-0.053554,0.035029,-0.006412,-0.031085,-0.004599,-0.020381,-0.060776,0.016099,0.038332,0.028258,0.056914,0.017822,0.009941};
  parameter real W2105[0:249] = {-0.040393,-0.050455,0.014159,0.014245,0.024811,0.005591,0.054954,0.061371,0.009711,-0.033302,-0.062727,0.020218,0.030644,-0.061804,0.028888,-0.013252,-0.022211,0.003970,-0.065905,0.058678,0.025866,-0.061146,0.041011,-0.003968,0.022815,0.057437,-0.040199,-0.019878,-0.040646,0.027828,-0.010676,0.032725,0.007322,0.011151,0.026713,0.032374,-0.050487,-0.045424,-0.062744,-0.038968,0.032353,-0.039088,0.014642,-0.021635,-0.009842,0.035514,-0.045230,0.018930,0.002424,-0.052800,-0.004748,0.060813,0.035584,-0.016783,0.052078,0.049096,0.052029,0.042718,0.031796,-0.015177,0.016652,-0.005644,-0.007964,-0.010183,0.046929,-0.032972,0.029229,0.032526,-0.006493,-0.020005,0.034094,0.003467,-0.060877,0.055076,-0.047345,0.003756,0.025933,0.041747,0.016450,-0.032815,-0.033445,0.008434,0.022022,0.052049,-0.056951,0.029140,0.007860,0.035234,0.048550,0.030135,0.041370,0.031871,0.037137,0.017159,0.025781,-0.058828,-0.053402,0.038074,-0.030868,0.027135,-0.038486,-0.014524,0.013547,0.017779,0.014324,-0.057509,-0.014317,0.018563,0.008502,0.039006,-0.024450,-0.014682,0.052732,-0.038593,-0.020734,-0.044221,0.055461,0.036715,0.057628,-0.013630,-0.054319,-0.017936,0.052016,-0.023942,0.022714,0.061126,0.012170,-0.034665,0.059569,-0.029430,-0.049949,0.038774,0.049994,0.016207,0.019188,0.043676,0.060655,-0.047322,-0.032017,-0.015551,-0.037788,0.047085,0.030921,-0.023826,0.017452,-0.020151,-0.004987,0.005655,-0.034117,0.011530,0.058629,-0.013138,0.025187,0.016585,0.006150,-0.033521,-0.053126,0.008527,0.047030,0.007192,-0.053166,-0.059861,-0.034896,-0.007021,-0.061813,-0.006476,0.045707,0.041337,0.005061,0.056512,0.017653,0.001605,-0.048846,-0.037537,-0.006801,-0.057076,-0.060158,-0.012588,-0.005370,0.038323,0.018119,0.017101,-0.017509,-0.056235,0.010770,-0.009363,-0.012176,0.006384,0.013976,-0.031860,0.032400,-0.047962,0.053504,-0.032802,0.043379,0.010235,-0.054798,0.057299,-0.021965,0.050516,-0.025221,-0.050070,0.023078,-0.044333,-0.058444,-0.027888,0.015918,-0.024229,-0.023040,0.005072,-0.026504,0.008314,-0.026295,0.019868,-0.013675,-0.044697,0.061523,0.039845,-0.037287,0.046889,-0.058759,-0.003465,-0.033304,-0.043929,0.049749,0.040884,-0.036895,0.000889,-0.054611,-0.047788,-0.058673,0.050785,0.040067,0.049479,-0.047576,-0.009033,-0.008635,-0.045651,-0.044590,-0.007002,-0.056392,-0.054377,0.011865,-0.022594,0.015647,0.041464,-0.057414,-0.042598,-0.011368,0.023423};
  parameter real W2106[0:249] = {-0.054581,-0.054248,-0.050276,-0.056409,-0.035762,0.042072,0.052915,-0.004729,-0.066353,-0.034980,-0.004226,0.005140,-0.037937,0.011675,-0.022337,-0.041149,0.009339,0.022254,0.031143,-0.009166,-0.049485,-0.043770,0.008415,0.041349,0.049208,-0.047962,-0.056102,-0.001256,-0.017311,0.054625,-0.026068,-0.067870,-0.000048,-0.018483,0.077008,-0.024617,0.013177,-0.001498,-0.008668,-0.025044,-0.016694,0.007999,0.006378,0.036909,0.016759,-0.034094,0.020520,0.042466,-0.039264,-0.029626,0.047876,-0.038339,0.050479,0.040986,-0.055072,0.041626,-0.045373,0.063546,-0.046702,0.034023,-0.049935,0.031928,0.035171,-0.022534,-0.056977,-0.021323,0.009083,-0.027132,0.033109,-0.008371,0.046528,0.055957,0.050667,-0.053476,-0.078313,0.064948,-0.012762,-0.040519,-0.017963,-0.028441,-0.041795,-0.036827,-0.057396,0.064171,-0.030958,0.059840,-0.034304,0.034499,0.047842,0.019395,-0.007165,0.013176,-0.024247,-0.048232,-0.008402,0.036500,-0.003298,-0.027896,0.048493,0.007065,0.023113,0.045314,0.004036,-0.055977,0.035005,0.026754,0.000624,-0.034217,0.005216,-0.051895,0.038406,-0.041369,0.027382,0.025512,0.024666,-0.046344,-0.034280,-0.013827,-0.006479,-0.051677,0.053188,-0.014996,-0.047290,0.047682,-0.007382,-0.050638,0.013617,0.032665,0.043154,0.014008,0.062396,-0.002913,0.045908,0.006408,0.036655,0.006282,-0.016675,-0.012744,-0.045119,-0.057839,-0.049486,0.005695,-0.020859,-0.034807,-0.054841,-0.049592,-0.029197,-0.021924,-0.021614,-0.067247,-0.055188,-0.002570,0.021228,-0.058640,0.042466,0.054310,-0.015310,-0.039724,-0.036417,0.005906,0.033536,-0.064981,-0.014926,-0.048221,-0.032958,0.048473,0.053129,-0.016762,0.062401,0.070676,0.056764,-0.022236,-0.027268,-0.040397,-0.017912,-0.032151,-0.013920,-0.016276,-0.005189,0.017183,-0.004327,-0.032507,-0.060268,0.044245,0.039742,-0.016888,-0.031415,-0.029324,0.039327,-0.032913,-0.006387,0.023791,-0.038340,0.009904,0.081762,0.001747,0.051522,-0.060391,0.008458,0.050749,0.018513,0.020963,-0.060209,0.030994,0.012924,0.001359,-0.027826,0.064100,0.062021,0.006800,-0.015380,-0.017939,0.005287,-0.021391,0.060926,0.062167,-0.025800,-0.020239,0.037431,0.004577,0.038896,0.056762,-0.061343,0.019977,-0.061120,-0.026500,-0.018934,0.021002,0.051104,-0.050056,-0.058599,0.059178,-0.016652,0.036921,-0.039922,0.035200,-0.040141,0.037512,0.003129,0.007429,0.015551,-0.068333,-0.045632,-0.023299,-0.014016,-0.017232,0.006048,-0.004341,-0.030140,-0.063337};
  parameter real W2107[0:249] = {0.006341,-0.057010,-0.042582,-0.004785,0.016712,-0.008431,-0.022082,0.025345,-0.038386,0.047495,0.040535,-0.019747,-0.010680,-0.003902,0.007579,0.033702,0.008573,-0.026272,0.041008,0.030783,0.044901,0.058631,0.005589,0.019222,-0.012237,-0.002609,0.047683,-0.031628,0.026894,0.055190,0.021705,-0.013924,-0.024771,0.048814,0.014415,-0.022900,0.056185,0.061117,-0.043428,0.019165,0.035490,0.013959,0.019096,0.041680,-0.002043,0.031280,0.044796,0.051193,0.025437,-0.034581,0.045095,-0.013169,-0.025304,0.045365,0.022531,-0.031722,-0.033116,0.006409,0.050676,-0.018961,0.048669,-0.053788,0.017009,-0.022372,-0.016535,0.029693,-0.034721,-0.032441,0.024598,-0.003420,-0.060901,0.050847,-0.004979,0.049232,0.008267,-0.076402,0.062497,0.023067,0.068609,-0.018745,0.049397,0.039593,-0.023645,-0.037951,-0.011089,0.049840,-0.021209,0.030592,0.054974,0.021819,-0.057806,-0.046167,0.015264,-0.056647,-0.005744,-0.089798,0.051528,0.016249,-0.060373,-0.057050,0.005585,0.037384,-0.052291,-0.001000,0.058493,-0.035664,-0.021991,-0.037766,-0.015380,-0.027008,0.057193,0.005993,0.061965,-0.004763,-0.058389,-0.059798,-0.002372,0.015778,0.030042,0.029623,0.000306,0.028056,-0.027424,-0.039317,-0.052260,0.048482,0.013785,0.055487,-0.057314,-0.029709,-0.037131,-0.035968,-0.058320,-0.005644,-0.013978,0.003506,-0.029045,0.031470,-0.016886,-0.058048,-0.051497,-0.046645,-0.049536,0.031516,-0.045557,0.039872,0.025602,0.047986,-0.057078,-0.042986,-0.056908,0.003819,0.017844,0.005208,-0.051031,-0.043305,0.044179,0.052383,-0.066374,-0.054252,0.043436,0.064701,-0.053159,-0.060216,-0.021287,-0.022356,-0.040582,-0.029821,0.051135,0.040960,-0.004573,0.078508,0.074334,0.070380,0.029364,-0.003161,0.036170,-0.024444,0.026374,0.005127,-0.035002,-0.042527,-0.057672,-0.063922,-0.044117,-0.024719,-0.014500,0.023877,-0.056789,0.000391,-0.049051,-0.016673,0.020121,0.019556,-0.027072,0.043382,-0.004510,0.058613,-0.024037,-0.010069,-0.048967,0.036422,-0.058484,0.053465,-0.036773,-0.007905,0.042931,0.012532,-0.013623,0.049539,-0.012711,0.058791,-0.036059,-0.028819,-0.047909,0.048782,0.041713,0.020807,0.000454,0.031678,-0.026754,0.022056,0.031134,-0.049914,-0.013208,-0.051904,0.000897,0.055790,-0.054295,-0.036160,0.013063,-0.050138,0.009715,-0.039731,0.035687,-0.003119,0.019896,0.026930,0.064100,-0.018164,0.065662,0.033564,-0.040246,-0.040760,-0.011446,0.064876,-0.015307,0.010772,-0.018273,-0.035154};
  parameter real W2108[0:249] = {-0.011960,0.038986,0.050740,0.063231,-0.045550,-0.008191,-0.004776,0.002837,0.061405,-0.005217,-0.021296,-0.057732,0.072279,-0.038052,0.021503,0.009223,0.013247,-0.025912,0.043519,-0.017539,-0.047784,-0.010274,-0.071586,-0.011766,0.051172,-0.056637,-0.042657,0.021851,0.038730,0.000815,-0.049074,-0.067871,-0.047335,0.055493,0.028806,-0.034515,-0.018660,-0.051079,0.030630,0.050432,-0.048654,0.015610,0.015284,-0.066017,0.047121,0.041832,0.014142,-0.003485,-0.007586,-0.059365,0.040506,0.008451,-0.019292,-0.022749,0.026062,-0.012918,-0.003083,0.004826,-0.004023,-0.055880,-0.008988,-0.013710,-0.069321,0.050200,-0.060247,0.053664,0.043153,0.005115,-0.009512,0.055049,0.043984,0.011491,0.031235,-0.006203,-0.075399,-0.024288,0.069509,-0.035143,0.020684,-0.019841,-0.051627,0.030413,0.041507,0.027872,-0.041174,-0.029866,0.023406,0.064756,0.017924,-0.040416,0.053839,0.002076,-0.022572,0.049834,0.055415,-0.052696,-0.009230,-0.051843,-0.025881,-0.054230,-0.006384,-0.047864,0.059069,-0.033868,-0.051284,-0.033359,-0.056217,0.022055,-0.036935,0.033278,-0.011563,0.012004,-0.009966,-0.042759,-0.047717,0.007126,-0.028394,-0.022787,0.013108,0.053606,0.012096,0.002007,0.014920,-0.027935,0.042807,-0.042587,-0.056886,0.024328,0.065597,0.045389,-0.023486,-0.065840,0.003445,0.043418,0.003072,0.034233,0.054567,0.016387,-0.063405,-0.043494,0.016917,0.059525,0.009380,-0.029744,-0.034836,-0.003745,-0.035360,-0.037253,-0.044559,-0.047883,-0.068274,0.013410,0.006511,0.038446,0.031641,-0.014897,0.007452,-0.057168,0.028462,-0.032153,0.037874,0.017665,0.031342,0.010805,0.015432,0.017335,-0.074920,-0.016919,0.030378,0.070982,-0.010084,-0.049565,0.013975,0.049597,-0.036412,0.045649,0.016510,0.003559,-0.047016,0.001482,0.046550,-0.000790,0.051294,-0.016188,0.042353,0.060650,-0.041046,0.051419,-0.010440,-0.052772,-0.058909,-0.051392,-0.022299,0.058798,0.069927,-0.041792,-0.013719,0.017764,0.052313,-0.021167,-0.009552,0.012083,-0.055949,-0.045299,-0.032682,-0.045229,-0.001924,0.033033,-0.045656,0.057162,-0.021757,0.037297,0.064305,-0.009511,-0.002024,0.047490,0.043561,-0.001193,0.030081,-0.045315,0.067229,0.039472,-0.039373,-0.039158,0.054348,-0.025236,0.046047,0.030474,-0.033249,-0.054940,0.054398,-0.062896,0.010393,-0.017083,0.001018,0.042213,-0.056518,0.034328,-0.044973,0.015508,-0.002379,0.028260,0.029453,0.021492,-0.057847,-0.050701,-0.044022,-0.008732,-0.024895,0.021701};
  parameter real W2109[0:249] = {0.027328,-0.040507,0.062594,-0.013532,0.020932,0.047750,0.046879,0.015207,0.007674,-0.017828,0.068979,-0.009901,-0.065063,0.044042,0.022531,0.014154,-0.050409,-0.047778,-0.014370,0.059512,0.064197,0.045996,-0.003831,-0.005706,-0.041386,0.002609,-0.035110,0.034401,0.051672,-0.006744,0.041219,0.009129,0.036956,0.050739,0.033442,-0.046077,-0.056525,0.056862,0.025132,0.036237,-0.027229,0.033398,-0.047105,-0.054938,-0.035079,-0.020084,0.026059,-0.023852,-0.042956,-0.021288,-0.016449,0.022160,-0.042263,0.058055,-0.029939,0.033150,0.054396,-0.015119,0.009179,-0.069884,0.017770,0.060625,-0.006423,-0.048003,0.036501,-0.002456,-0.024900,0.011678,-0.018743,-0.035374,0.003628,-0.052009,-0.012640,0.029251,-0.013645,-0.000861,-0.039405,-0.037011,-0.068512,0.053537,0.044750,-0.043357,0.028546,-0.010508,-0.066439,0.035642,-0.048986,0.039119,0.016597,-0.041796,-0.044762,-0.042025,-0.019946,0.043057,-0.019030,-0.036926,-0.004307,0.007216,-0.060064,0.017153,-0.016845,0.028119,0.050502,-0.016235,-0.030015,0.057156,-0.027014,-0.048360,-0.006040,-0.017184,-0.005873,0.004068,-0.017528,0.029964,0.061127,0.059645,0.045498,-0.040216,-0.008734,0.054284,-0.063782,0.064639,-0.039908,0.064289,0.035946,-0.000613,0.008026,-0.040875,0.039615,-0.048486,-0.049213,-0.029474,-0.002616,-0.029226,-0.059756,-0.024046,0.043650,0.044805,0.050281,-0.001092,-0.037643,0.063675,0.011558,0.006123,0.000822,0.018479,-0.047696,-0.048418,-0.044066,0.010278,-0.051213,-0.052808,0.056664,0.002820,0.053090,0.039979,0.049983,0.040682,0.011324,0.040943,0.002026,0.029449,-0.066178,0.024073,-0.040485,0.059146,0.022001,0.042944,-0.003975,0.044493,0.009826,0.046778,-0.039184,-0.013683,0.022601,-0.012988,0.043393,-0.062680,0.002290,-0.014464,-0.031601,-0.022477,-0.057643,0.051849,-0.071566,-0.061408,-0.031098,0.052127,0.055876,0.027792,0.053574,0.066624,-0.020976,0.028854,0.046527,0.057688,-0.001982,-0.062708,0.041610,0.036979,-0.053777,-0.006697,0.055605,0.020893,0.053379,0.033017,-0.051728,0.046821,-0.009965,-0.045797,0.047539,-0.038104,0.001782,-0.047997,-0.014140,-0.062898,-0.011225,-0.050189,-0.009088,0.011179,-0.034302,0.028964,-0.039462,-0.004645,-0.043613,0.041671,0.047431,0.037998,0.051622,0.020953,0.020817,0.035363,-0.025196,-0.003122,-0.026385,0.044860,0.045375,0.008612,0.038847,0.062334,0.044132,-0.038762,-0.032891,-0.041440,-0.046387,0.020703,0.015815,-0.052738,-0.036805,0.024282};
  parameter real W2110[0:249] = {0.024534,0.033389,-0.044373,-0.054173,0.027000,0.056581,0.004937,-0.039802,0.029473,-0.043073,0.047662,-0.016061,0.045288,0.012368,0.012946,0.048626,0.014311,-0.011485,0.056008,-0.008384,0.058773,0.031101,-0.022369,-0.043304,-0.049626,-0.020170,0.010203,0.038483,-0.031166,0.012098,0.020286,-0.018911,0.053038,0.016596,-0.030806,-0.005316,-0.003642,-0.011206,-0.002763,-0.066459,0.044387,-0.024582,-0.025731,0.043860,-0.006282,-0.033628,0.018367,0.054275,-0.004878,-0.025349,0.076508,0.020044,0.001889,-0.063726,0.033251,-0.062050,0.064777,0.061927,-0.051497,-0.070550,0.011959,-0.054725,0.002140,0.049770,0.066233,0.052644,0.005551,0.033949,0.013278,0.046421,0.036170,0.053202,-0.059911,-0.043060,0.059283,-0.018187,-0.064653,0.041210,0.029281,-0.054834,0.026885,0.038634,-0.003534,-0.086586,-0.018921,0.035853,0.010963,-0.049787,-0.040219,0.012088,-0.001299,-0.001916,-0.050415,0.016325,0.008872,-0.006514,0.051111,-0.021441,-0.006390,-0.041864,0.047642,0.044950,0.045252,0.026320,-0.047735,0.028484,0.039177,-0.042259,0.046732,0.054339,0.033537,0.029668,0.024805,0.043976,-0.012630,-0.038473,0.037253,0.031645,0.019752,0.045314,-0.056778,-0.033530,0.038362,-0.053089,-0.001757,-0.020535,-0.004582,-0.050303,-0.034168,-0.032494,-0.046617,0.016006,-0.061295,-0.054839,-0.070368,-0.010824,0.039621,0.031598,0.006603,-0.022341,-0.028424,0.009699,0.053678,0.027934,-0.036126,-0.009185,-0.044934,0.040900,-0.054093,-0.050026,0.021213,-0.015866,0.037102,-0.030804,-0.016074,-0.045712,0.000207,0.053725,0.039394,-0.026217,-0.058026,-0.009027,0.057082,-0.007344,-0.002944,0.059939,-0.007423,-0.047806,0.022363,-0.019442,0.032712,0.059625,0.071638,-0.015325,0.030096,-0.018459,0.049897,-0.023143,0.013517,0.006214,-0.053206,0.052061,-0.011464,0.048955,-0.008105,-0.054498,0.000424,0.068331,0.058192,-0.041112,-0.020585,0.070294,0.001552,-0.066548,-0.010239,-0.036494,0.050396,0.032866,0.046159,0.012880,0.003548,0.003645,0.035890,-0.034642,-0.066382,0.063315,-0.021880,0.016104,-0.023851,0.006089,-0.012165,0.051678,0.051721,0.007656,-0.039222,-0.036875,0.043886,0.028895,0.065953,0.041373,0.032073,0.047043,-0.055375,0.028014,-0.032472,0.056270,0.025890,-0.032078,0.026841,-0.046646,0.046371,0.044278,-0.018548,-0.051750,-0.024893,0.008571,0.074671,-0.067124,0.030719,0.055841,0.080741,-0.014834,-0.028353,0.027447,0.028713,-0.001504,0.020651,-0.065685,0.044790,-0.008364};
  parameter real W2111[0:249] = {-0.029463,0.033300,-0.001636,-0.041189,-0.040581,0.038989,-0.035535,0.049084,0.000825,0.012910,-0.014612,0.018321,-0.033475,-0.005140,0.039989,-0.062187,0.030953,0.009110,0.016496,-0.048844,0.037380,0.024973,0.017240,-0.027669,0.042710,-0.046385,-0.057386,-0.007416,0.012716,0.028872,0.005591,-0.024484,0.063888,0.034014,-0.020255,0.045267,0.031562,0.015265,0.063358,-0.048242,0.042287,0.063523,0.005978,-0.003928,0.014979,0.001796,0.035210,-0.044442,0.050529,0.058198,0.009265,-0.028089,-0.020717,0.046434,-0.005875,0.011049,0.015757,0.059810,0.044274,0.062948,0.037089,0.034758,-0.045985,-0.045110,0.008887,0.041948,-0.036296,0.000989,-0.053021,-0.027613,0.013373,0.016885,0.034557,-0.003070,0.064523,-0.050384,0.056427,-0.031015,0.014498,-0.062639,-0.019786,-0.018522,-0.021817,-0.023896,0.027568,-0.036640,-0.002129,-0.023634,-0.029516,0.042097,-0.042320,-0.057924,0.043042,-0.025098,0.004252,-0.032185,-0.002359,0.017623,0.006633,0.026720,0.036758,-0.018055,-0.023381,-0.051954,0.027940,0.018701,0.053907,0.012832,-0.007198,-0.053463,0.035794,-0.052008,-0.006467,-0.062130,0.035260,0.040794,-0.015978,0.057464,0.046684,0.046521,-0.044070,0.047153,-0.041117,0.048418,-0.055581,-0.044172,0.050331,-0.055368,-0.016050,-0.012872,-0.031873,-0.051879,-0.062440,-0.029912,0.024141,0.023152,0.000218,0.059095,0.019681,-0.001880,-0.027203,0.012773,-0.029418,-0.008428,0.001098,0.061887,-0.021692,-0.015585,0.017434,-0.034166,-0.014709,-0.044015,-0.039045,-0.002491,-0.006936,-0.005631,0.004833,0.045713,-0.024109,-0.009905,0.011545,-0.061335,0.017626,0.007317,-0.015020,0.005927,0.054214,-0.015115,-0.009918,-0.061795,-0.015947,0.056751,0.063591,-0.007094,-0.000781,0.038591,-0.062778,-0.029432,-0.019808,0.049519,0.065742,-0.030746,-0.053611,-0.031857,-0.022625,0.003028,0.065656,-0.033194,0.058089,-0.005652,0.036954,0.000898,-0.063596,0.021578,-0.031852,-0.059699,-0.000926,-0.008565,0.004788,-0.057557,-0.034051,0.004527,0.024693,0.002022,0.035112,-0.045038,0.025465,-0.028011,0.051691,-0.019833,-0.042424,0.039099,-0.052242,-0.026129,-0.051710,0.007552,0.018067,-0.030772,0.050111,0.035030,0.044012,0.019520,0.045674,-0.051693,-0.047562,0.011888,-0.019578,-0.036188,-0.041454,-0.038333,0.020914,0.053135,0.030099,-0.031917,-0.037990,-0.054398,-0.045777,-0.007613,0.007605,0.031672,-0.030436,0.031389,-0.018868,0.064222,0.023200,-0.057103,-0.028374,-0.049154,0.004130,0.014135};
  parameter real W2112[0:249] = {0.060379,-0.045969,-0.021941,0.061061,-0.039065,0.000665,0.021303,0.004334,0.041387,0.000478,-0.024086,-0.034201,-0.034185,0.004774,-0.061005,0.011086,-0.023229,-0.028278,-0.011084,-0.050787,-0.052120,0.054909,-0.012493,0.022497,0.005989,0.055466,0.046450,-0.018541,0.026697,-0.030219,-0.040881,-0.033178,0.030044,0.016599,-0.034506,-0.004455,-0.051565,0.036163,0.030589,0.036174,-0.002993,-0.046067,0.023011,-0.023437,0.031067,-0.027787,-0.050099,-0.048249,0.011431,0.057043,-0.007430,0.008855,0.048237,0.051825,0.053031,-0.002206,0.041020,0.014894,-0.047592,-0.023403,0.033518,0.045896,-0.036385,-0.056531,-0.040010,-0.054822,-0.004946,0.058498,-0.048908,0.041792,-0.032520,0.023129,-0.003064,-0.054794,0.057402,-0.035537,-0.000520,0.043483,-0.035308,0.024262,-0.060410,0.035524,0.021713,-0.019322,-0.002007,-0.044149,-0.020230,0.003995,0.010922,0.042897,-0.012235,0.046345,0.036315,0.061805,-0.032683,0.061893,0.010568,-0.059046,-0.052557,0.056923,0.014497,0.056499,0.037177,0.039665,-0.034179,-0.037822,-0.058494,-0.025333,-0.024847,0.017104,-0.036245,0.059258,-0.019776,-0.033843,0.024771,-0.008680,0.008398,-0.008828,-0.006818,-0.055451,-0.004705,0.033488,0.040807,0.024179,-0.024772,0.065746,0.029163,0.023705,0.043572,0.005169,0.059410,-0.006986,0.037713,0.018446,-0.003001,0.022459,0.049848,0.005747,-0.042374,0.004359,-0.031658,0.019586,-0.043631,0.019567,0.008470,0.043988,0.067985,-0.045835,-0.017502,0.049065,0.020815,-0.001426,0.010936,-0.004970,-0.051916,0.028710,-0.013628,0.031077,-0.011765,0.015686,0.018609,-0.056285,-0.047766,-0.051078,0.036933,-0.006095,-0.028063,0.052271,0.017361,0.045019,0.017058,-0.047684,-0.019246,-0.055995,-0.057780,-0.025222,-0.050652,-0.043004,-0.012182,-0.038110,0.011681,-0.056380,0.061155,0.033386,0.051849,0.012824,0.001565,0.021648,-0.030591,0.036547,0.053169,-0.026003,0.013925,0.042502,0.002518,0.056450,-0.031026,-0.008170,-0.025684,0.035330,0.004072,-0.031485,-0.036736,0.013817,-0.000614,0.046023,0.026906,0.001653,-0.018698,-0.002214,-0.006044,0.009373,0.013764,0.036623,0.060244,0.037896,0.053463,-0.020528,-0.029572,0.003897,-0.013139,0.039615,0.023154,-0.032042,0.002684,-0.021478,0.059930,-0.049708,0.063067,-0.052801,-0.017236,0.009199,-0.049417,0.056007,-0.006089,0.027170,-0.003221,0.005915,-0.040162,-0.013186,0.057098,-0.049387,0.003820,-0.033943,0.051240,-0.010649,-0.047130,-0.001325,-0.049103,-0.050810};
  parameter real W2113[0:249] = {-0.043984,-0.058472,0.024284,0.036821,-0.004422,-0.031163,-0.049002,-0.060292,-0.039717,0.003663,0.008336,-0.010214,0.015080,0.052031,0.054736,0.034894,-0.056580,-0.041889,-0.053042,-0.032235,-0.000968,-0.007221,0.046295,0.011084,0.019437,-0.021901,0.041960,0.016372,0.057180,0.009303,-0.039015,-0.015870,0.023388,0.022421,-0.011569,0.056464,-0.005093,-0.017472,-0.023156,-0.021988,0.038650,-0.037514,-0.010514,0.016846,0.035446,-0.040004,0.015408,0.034900,-0.063586,-0.041479,0.030146,0.006225,-0.065718,-0.005403,0.052171,0.005280,-0.016562,-0.052685,-0.029913,-0.032069,-0.058114,0.038015,0.004139,0.025278,-0.044480,-0.030642,0.010969,0.060395,-0.050203,0.059649,-0.039544,-0.019695,-0.003007,-0.007989,0.040313,0.037627,-0.049347,-0.026467,-0.029123,0.015211,-0.009206,-0.008920,0.010600,-0.019442,0.033810,-0.055904,-0.018418,-0.032649,0.058823,-0.058805,-0.026864,-0.048316,0.017830,-0.062292,-0.032901,-0.005987,0.020829,0.024984,-0.016174,0.062121,0.012296,0.031097,0.051460,0.037972,0.006581,0.021582,-0.050474,-0.016553,-0.032025,0.051934,-0.028805,-0.032942,0.036370,0.043963,0.054112,-0.008511,0.004282,-0.014153,-0.009520,-0.036427,-0.030135,-0.017650,-0.038736,0.029483,-0.027901,-0.012023,0.042079,-0.052199,-0.016759,0.052031,0.000245,-0.030506,-0.047951,-0.013640,0.000547,0.024423,-0.055525,0.037268,-0.044337,0.049311,0.023808,0.033306,0.015578,-0.048773,-0.033371,-0.043018,0.022376,0.056467,0.038732,0.025688,0.013945,0.066068,0.004702,0.007964,0.048816,0.052920,-0.056585,-0.036169,0.036844,0.010778,-0.002481,-0.023342,-0.000180,-0.005619,-0.052158,-0.016536,-0.034019,-0.060816,-0.049120,-0.060450,0.043994,-0.048985,0.052626,-0.030640,0.051054,-0.049642,0.039005,0.004618,0.011360,0.024799,-0.044097,0.052565,0.019244,-0.010984,0.027126,-0.017300,0.056984,0.012399,0.047168,-0.053482,-0.031692,0.053599,-0.061182,-0.033951,-0.009157,-0.021842,0.034772,-0.015439,0.008608,-0.038075,-0.030670,0.032121,0.006115,0.035032,0.030355,-0.042075,0.038036,-0.010384,0.024570,-0.045296,-0.021851,-0.023277,-0.022161,0.038962,0.029871,-0.005143,-0.010343,-0.054054,0.005455,-0.049630,-0.047501,0.059304,-0.040187,0.038937,0.049151,0.035292,-0.025289,-0.048767,-0.006362,-0.002566,0.052910,-0.002769,0.050388,0.040706,0.005731,0.008235,-0.029303,-0.014642,0.007521,-0.050421,0.065339,0.000848,-0.034162,0.011502,0.009294,-0.029459,0.008975,-0.010233,0.011838,-0.014217};
  parameter real W2114[0:249] = {-0.060199,0.024359,-0.006954,-0.039351,0.052566,-0.061319,0.046528,-0.026917,-0.055718,0.017097,-0.033278,-0.035799,0.027703,-0.030025,-0.022510,-0.037041,-0.016555,-0.052973,0.042826,0.032762,-0.034434,0.057767,0.045210,-0.055649,-0.037099,-0.023002,0.039268,-0.056248,-0.005389,0.051004,0.026870,0.049750,0.052108,-0.054105,0.049819,0.013891,0.070413,0.071064,-0.003713,0.044570,-0.023215,-0.048257,-0.008552,0.027064,-0.026303,-0.058994,-0.013753,-0.004435,-0.052867,0.000950,0.061332,0.048732,0.059758,-0.037211,0.011008,-0.073097,0.030931,0.002234,-0.068106,0.011616,-0.023887,-0.048505,-0.043944,0.053123,-0.004728,0.057559,0.001768,-0.040884,0.040541,0.039232,-0.048458,0.002850,-0.064248,-0.041070,0.025850,-0.036781,0.019179,0.011615,0.049696,0.033710,-0.033156,0.002666,-0.049932,-0.012154,0.015164,-0.007450,-0.015322,0.014083,-0.008564,-0.007069,0.056867,0.055061,0.004881,0.037842,-0.007594,-0.035840,0.071405,-0.046288,-0.031244,0.025414,-0.017343,-0.020351,-0.013143,0.001536,0.004161,0.032225,0.016540,0.014676,-0.026274,-0.014374,-0.032963,0.067230,-0.000865,-0.027219,0.028539,-0.060126,0.007024,0.033364,0.022672,-0.025619,0.028693,-0.053721,0.039958,-0.000880,0.013096,-0.008240,-0.008189,-0.000893,0.062581,0.048264,0.020940,0.024627,0.065716,0.028681,-0.049882,-0.057746,0.011455,0.027084,0.030901,-0.055088,-0.021123,-0.062230,-0.001296,0.067778,0.016707,-0.025667,0.035700,-0.031242,0.033456,0.077004,0.028767,0.005657,-0.015593,0.050490,0.057703,-0.001263,-0.060999,0.016320,0.044204,0.054759,-0.056647,0.068557,-0.000701,-0.031368,-0.034554,0.051529,-0.004412,0.029610,-0.051484,0.000980,-0.001651,-0.032912,0.049354,-0.041993,-0.030500,0.018561,0.022755,-0.041171,0.007684,-0.038646,0.047708,-0.045545,-0.044151,-0.043882,-0.000956,0.024864,0.025533,0.050638,-0.012316,0.052990,-0.024166,-0.042931,-0.009696,0.045374,-0.024553,0.070486,-0.012303,-0.008960,-0.038567,-0.049062,-0.052711,0.006041,0.011198,-0.051195,0.056147,-0.011652,0.048209,-0.001303,-0.015021,-0.059416,0.015295,0.034391,-0.037478,-0.015362,-0.040491,-0.041135,0.068884,-0.010581,0.031468,0.036548,-0.000201,0.042306,-0.049257,-0.050230,0.043755,-0.032837,0.025027,0.044577,-0.050931,-0.001338,-0.005326,-0.007911,-0.037699,-0.064292,0.026378,-0.061767,0.057973,0.025546,-0.020062,-0.032005,0.064152,0.028639,-0.047930,-0.037370,-0.003130,-0.012516,-0.051919,0.000471,0.031555,0.077986};
  parameter real W2115[0:249] = {0.004845,0.015213,0.042582,0.021452,0.005243,-0.034301,0.004946,-0.054458,-0.022723,-0.020586,-0.019330,0.002369,0.059056,0.006189,-0.053956,-0.026620,-0.034553,0.051624,0.039020,0.033200,-0.006242,-0.060704,-0.024019,0.004787,0.030816,-0.050449,0.000991,0.014910,-0.019178,-0.053905,0.005712,-0.054253,-0.002055,-0.031793,-0.021952,0.036177,-0.013032,0.003360,-0.004999,-0.047634,-0.016121,-0.032461,0.018767,-0.048268,-0.016103,0.022208,0.061378,-0.016803,-0.018758,-0.034006,-0.007545,-0.063597,-0.038501,0.021822,-0.045725,0.040412,-0.046201,0.056928,-0.058817,-0.048659,0.024656,0.045323,0.000235,-0.002894,-0.021914,-0.064520,0.004121,0.051918,-0.038405,0.020780,0.061129,-0.046555,0.030198,0.060992,-0.055132,0.039730,0.034199,0.054899,-0.048110,0.029313,-0.050259,0.035695,-0.003932,-0.022690,0.005686,-0.018840,0.054935,0.016419,0.032262,-0.063656,-0.002534,-0.049036,-0.050317,0.025339,-0.027795,-0.035160,0.011148,0.040890,-0.043540,-0.009971,-0.060558,-0.041939,-0.002883,0.006953,-0.019861,-0.033463,0.036000,-0.025578,0.020545,-0.037232,0.022597,0.003028,0.045479,0.015348,0.057494,-0.015459,0.038726,-0.006449,0.024315,-0.034271,-0.064710,-0.039909,-0.052012,-0.026989,-0.015501,-0.028275,-0.004292,-0.018898,0.032511,-0.033091,0.057135,-0.049860,-0.055819,-0.020105,0.059127,-0.036438,-0.010720,-0.002668,-0.065467,-0.024570,0.059219,0.027591,-0.063832,-0.054554,0.006929,-0.001912,-0.000593,-0.021450,-0.048946,-0.016800,-0.039985,-0.056508,-0.012820,-0.062423,-0.026181,-0.026248,0.036290,-0.053863,-0.029939,0.043232,0.057719,0.003154,-0.014139,0.014424,0.026616,-0.041309,0.021719,-0.001648,-0.043341,0.010325,-0.033326,-0.005184,0.014370,-0.034521,-0.057505,0.007457,-0.037654,-0.050163,-0.036322,-0.038871,-0.025408,-0.049571,0.049258,0.030341,0.070029,-0.026047,0.034376,-0.008965,-0.040804,0.042317,-0.003515,0.069025,-0.043301,0.040612,-0.015835,-0.047300,-0.039473,0.039168,-0.012936,-0.025131,-0.022327,0.034684,0.038216,-0.016326,0.041900,0.048656,0.019482,-0.029407,-0.060831,-0.050636,-0.003437,-0.050027,-0.022852,0.051928,-0.004822,0.012843,-0.056010,-0.002619,0.004946,0.011766,0.031768,-0.037129,-0.026599,0.020745,-0.052259,0.010019,0.052786,-0.045528,0.000712,-0.004012,0.054578,-0.049609,0.011924,-0.024746,0.051165,-0.017599,-0.053540,-0.033195,-0.047524,0.023727,0.056097,0.005641,-0.026019,0.012682,-0.054754,0.006375,-0.029681,-0.002386,0.046283,-0.059799};
  parameter real W2116[0:249] = {-0.031495,-0.046281,0.050701,0.040357,-0.008794,0.061418,0.035022,0.024754,0.023604,0.025541,-0.020838,0.027686,0.027484,-0.019632,0.044198,-0.028193,-0.033354,-0.000958,-0.034159,-0.018924,-0.016736,-0.006670,-0.038355,-0.010129,-0.005388,0.007106,0.007892,-0.037114,-0.034146,0.028683,0.028450,-0.046601,0.036311,0.061474,-0.033097,0.057138,0.024361,0.055983,0.054797,-0.022768,0.044751,-0.018397,0.029456,-0.011119,-0.054828,-0.054673,-0.023147,-0.062322,0.011070,0.037533,0.017855,-0.059188,-0.000864,-0.042628,0.054817,0.041414,0.031530,-0.035054,0.007033,0.036548,0.051470,-0.044511,0.003416,0.059073,0.020383,-0.021356,0.011746,-0.005289,0.012524,0.060721,-0.038093,-0.055860,0.034094,0.010966,0.024560,-0.020235,0.020489,-0.044615,0.046856,0.028813,-0.047233,-0.000499,-0.043757,-0.031515,-0.043493,-0.007016,-0.003863,-0.016941,-0.029100,0.051188,-0.028495,-0.004561,0.043399,-0.014816,0.047179,-0.048396,-0.033735,0.008326,0.044302,0.015836,-0.001804,-0.057470,-0.047573,-0.028351,0.050937,0.032141,-0.013376,0.023743,0.053855,0.035446,0.003234,0.020209,0.050752,-0.057629,-0.029679,0.010401,0.058403,-0.044516,0.049687,0.035663,-0.048781,-0.028803,-0.061867,-0.035522,-0.062452,-0.040455,0.050706,0.014734,-0.022699,0.000333,0.005299,0.030090,0.027994,-0.048309,-0.027739,0.013624,0.014651,-0.003091,0.021038,0.051866,0.044450,-0.006906,-0.055726,-0.043514,-0.056122,-0.037463,0.050160,-0.045324,0.057784,0.034500,0.047936,-0.014950,0.027941,-0.024187,-0.014656,-0.007669,-0.039956,-0.004681,0.049309,0.059050,0.046018,-0.013410,-0.040439,0.062862,-0.022754,-0.038708,0.023062,-0.035682,0.012792,0.009547,0.026862,0.012253,-0.023460,-0.057396,0.060026,-0.021754,0.004234,-0.046936,0.045880,-0.057133,0.047618,0.006504,0.014718,0.025067,-0.059326,0.041351,0.001812,0.034026,0.036045,0.027444,0.005255,-0.027973,0.004325,-0.028507,0.006543,0.051513,0.056919,0.030739,-0.008398,0.030359,0.063332,0.008343,-0.013854,-0.008539,0.050620,-0.011514,-0.048296,-0.049279,-0.025579,0.055343,-0.033487,0.006099,0.042121,-0.030757,-0.039830,-0.032179,0.060136,0.029194,0.045363,0.024145,-0.019327,-0.000989,0.015096,0.063623,0.061420,-0.045883,0.036791,0.061877,0.056543,-0.043791,0.027432,-0.007594,0.040111,0.035523,0.028362,-0.035699,-0.056756,0.005950,0.046671,-0.015212,-0.015263,-0.005884,-0.028107,0.021542,0.023778,-0.061710,-0.023289,0.051994,0.032439,0.043033};
  parameter real W2117[0:249] = {0.006089,-0.057922,-0.043097,-0.043250,0.051255,0.051735,-0.019569,-0.033942,0.002524,0.040874,-0.014185,0.047403,-0.048202,-0.031083,-0.047821,-0.029038,0.033431,-0.029103,0.012805,0.017680,0.035271,0.058594,-0.048774,-0.000331,-0.008467,-0.044210,0.045250,0.031647,0.006570,0.026352,-0.016301,0.058101,0.026527,-0.057687,-0.074864,0.026858,0.018294,-0.020500,-0.059018,0.032158,-0.057211,-0.018678,-0.037938,0.066402,-0.050777,0.002300,0.027654,-0.036423,0.048523,0.054183,0.053704,0.049827,-0.020130,0.018718,-0.018398,0.011780,-0.059144,-0.030905,0.035068,-0.000137,0.032133,0.031019,0.003441,-0.047088,0.032575,-0.023191,-0.004776,-0.025078,-0.041933,0.014896,-0.026957,-0.022549,0.055485,0.018718,-0.012015,-0.041217,-0.016667,-0.061794,0.013323,0.009955,0.045130,0.018527,-0.055603,-0.039913,-0.002601,-0.010246,-0.006207,0.047370,0.008876,0.004972,-0.031495,0.027047,-0.019672,-0.063729,0.038924,0.013471,0.042174,-0.031493,-0.038664,0.051846,0.020496,0.021049,0.002284,-0.046760,0.014492,-0.025834,0.006456,0.001234,0.037797,-0.023059,0.022960,-0.022265,-0.053145,0.052970,0.041490,-0.038873,0.053893,0.007561,-0.061508,-0.005445,0.001275,0.062878,0.046351,0.031361,-0.047285,-0.004740,0.032940,0.052837,-0.046018,-0.011474,0.023062,0.019840,-0.052784,-0.013823,0.019838,-0.044745,-0.033017,0.018838,-0.010948,-0.002474,-0.017666,-0.050666,0.055391,-0.040255,0.005480,-0.009323,0.050126,-0.038943,0.036360,-0.017130,0.016371,-0.019210,-0.018381,0.002071,0.032069,0.032708,-0.000631,0.046874,-0.018843,-0.012821,0.028680,0.047736,0.032174,-0.040594,0.054218,0.046333,-0.043631,-0.030693,-0.020771,0.036870,0.022960,0.000807,-0.018988,-0.033821,0.022988,-0.013555,0.054391,0.035337,-0.024955,-0.039613,-0.016814,-0.036353,-0.009855,0.027840,0.047333,0.000647,-0.059575,-0.000056,-0.033843,-0.032487,0.059985,0.052114,-0.022708,-0.046507,-0.046537,-0.023341,0.055355,-0.049934,0.035345,-0.015434,-0.034742,0.042651,0.062009,-0.017045,0.041523,-0.047066,0.044801,-0.022963,-0.002151,-0.050877,0.041803,0.059034,-0.040052,0.060019,0.021777,0.017235,0.005799,-0.031050,0.054136,-0.021211,-0.015016,0.049317,-0.037521,-0.026379,0.008395,-0.046806,-0.037735,-0.002600,0.004441,0.016461,0.071954,0.054901,-0.004919,0.025321,0.015201,-0.025919,0.001037,0.023186,0.031398,-0.011834,-0.051556,0.050373,-0.025331,-0.004868,0.064350,-0.037858,0.037970,-0.023498,-0.014584,-0.054792};
  parameter real W2118[0:249] = {-0.028248,-0.053552,-0.024183,-0.067366,0.002580,0.036885,0.035477,0.010321,0.061383,0.025650,0.059201,0.033920,0.001452,-0.039824,-0.066465,-0.044374,0.056095,-0.029905,0.005035,-0.038009,-0.055965,0.017487,0.065009,0.031954,-0.024520,-0.014457,-0.006887,-0.047942,0.024574,0.027508,-0.035089,0.026097,-0.061513,-0.041105,-0.027292,-0.006045,0.052258,-0.047845,-0.007100,-0.053251,-0.035708,-0.045018,0.060910,0.036176,-0.040326,0.001080,-0.021049,0.022851,-0.004694,-0.025847,0.041411,0.020302,-0.031881,0.014894,0.013424,-0.005142,0.042121,-0.063884,-0.043883,0.009289,0.045438,0.063715,-0.008864,-0.021180,0.011781,0.041334,0.035640,-0.005272,0.020295,-0.036392,-0.019236,0.000874,0.032195,0.027777,0.029486,-0.076353,0.010639,-0.028416,0.036744,-0.032980,-0.010047,0.019197,-0.025032,0.018609,-0.012056,-0.013802,0.031973,-0.045901,-0.022372,-0.061197,0.029969,0.028447,0.058627,0.028646,-0.035826,-0.054111,-0.058837,-0.002151,0.031491,-0.003601,-0.047052,-0.034422,-0.024140,-0.039536,-0.015256,0.056492,0.060784,-0.004049,-0.019107,-0.018704,-0.000613,0.054799,0.028347,0.030300,0.026720,0.012343,0.045476,0.055103,-0.003239,0.031458,-0.028667,0.038730,0.002008,0.041644,0.040132,-0.035554,0.041426,0.040575,-0.075882,-0.065823,0.031977,-0.019058,-0.058135,0.045047,-0.051314,-0.001431,-0.053818,-0.004975,-0.026614,-0.028280,-0.031574,0.011801,-0.031820,-0.052441,-0.009621,0.056797,0.041138,-0.059744,0.025261,0.036909,0.017647,-0.034296,-0.012576,0.044560,0.016646,-0.005737,0.000199,-0.049931,-0.017347,0.030873,0.049006,0.021844,0.037171,0.052162,0.026813,0.030948,0.041556,0.050148,0.033265,-0.018409,0.033715,0.000765,0.054431,0.050142,-0.016132,0.058652,-0.015597,-0.032359,0.057606,0.009581,-0.043641,-0.058849,-0.049865,0.067017,-0.043119,-0.044306,-0.061042,0.037230,0.002780,0.041699,-0.059981,0.066120,-0.051939,-0.053141,-0.041094,0.017585,0.030282,-0.006968,0.053112,-0.079020,-0.015327,0.005409,-0.019811,-0.012477,0.046718,0.043247,-0.048080,0.028060,0.027553,0.021551,-0.060074,0.060910,-0.042842,0.024167,0.023972,-0.035449,-0.003467,0.051960,-0.020194,0.002087,-0.021637,-0.021922,0.001314,-0.037833,-0.013281,0.007051,-0.018639,-0.022528,0.043867,0.049335,0.013827,-0.036158,0.019162,-0.061521,-0.059528,0.020735,-0.056905,-0.017350,0.053610,0.048717,-0.040949,0.055646,0.041776,-0.009022,0.009463,0.023244,0.049529,-0.013980,0.049095,0.022386};
  parameter real W2119[0:249] = {0.010069,0.047814,-0.054570,0.044348,-0.011764,-0.021772,-0.037789,0.015141,0.045076,0.046045,-0.052329,0.020188,-0.026478,0.033921,-0.011007,0.030969,0.010098,0.007961,0.030329,0.020401,0.052253,0.050107,-0.019474,0.005426,-0.024726,0.058205,0.020622,-0.007558,0.052296,0.062930,0.034726,-0.058590,0.043931,-0.007268,0.029642,0.016236,-0.063871,-0.014215,0.037345,0.044361,-0.010534,0.022628,0.040037,0.018499,-0.029746,0.022324,0.035340,-0.017420,-0.035662,-0.004846,-0.038803,0.055399,-0.012045,-0.003832,-0.012978,-0.051005,-0.003472,-0.052916,-0.027368,0.024971,-0.006359,0.045619,-0.048592,0.058246,-0.064572,-0.021565,0.002593,0.056048,-0.017614,-0.001687,-0.022644,-0.021108,0.045272,-0.061822,0.058066,0.062422,-0.025580,0.013563,0.007259,0.047673,-0.023364,-0.041470,0.003916,-0.059132,-0.007154,-0.018794,-0.018774,0.022022,-0.050681,-0.028341,-0.039268,-0.041066,-0.003567,-0.055082,-0.058646,0.039257,-0.021694,-0.022774,-0.019282,-0.055093,-0.044180,0.021423,0.029139,0.009863,-0.055243,0.018483,-0.048710,0.020347,0.008585,-0.050413,0.049165,0.030057,0.059596,0.027396,-0.064125,-0.023459,-0.047746,0.045560,-0.000741,-0.045301,-0.036616,-0.023829,-0.047972,-0.048159,-0.042882,-0.001259,0.029105,-0.029814,0.059267,0.038144,0.012795,-0.006426,-0.012699,0.044898,-0.051095,0.044419,-0.037123,-0.034993,0.019386,-0.009367,-0.006439,0.034055,0.025538,-0.057994,0.044013,-0.021668,-0.041923,0.015959,-0.025741,0.054142,0.001166,-0.016260,-0.014295,-0.016355,0.061062,-0.032484,-0.042061,-0.026713,-0.012304,0.028265,0.056701,-0.032491,0.022939,0.000694,-0.040001,-0.006383,0.050460,0.043142,0.041489,0.007208,0.031077,0.053209,0.006526,0.046733,-0.053574,-0.054390,0.015982,0.001499,0.057965,0.018062,-0.007384,-0.048608,0.014863,-0.026023,-0.060929,-0.030673,-0.037826,-0.018278,0.056041,0.051754,-0.053651,0.047445,-0.030052,-0.027665,-0.049126,-0.044404,0.053464,-0.053545,-0.033368,-0.054937,0.031537,0.017824,0.049264,0.031065,-0.047939,-0.001042,-0.049853,0.041877,0.049865,-0.061118,-0.058562,0.017551,-0.033601,0.052772,0.051191,-0.025376,-0.038629,0.013053,-0.045524,-0.042466,0.007440,0.026977,0.050628,-0.034340,-0.015808,0.064771,0.053991,0.038874,-0.059258,-0.032814,-0.015518,-0.025560,-0.026063,0.008827,0.000430,-0.019994,-0.010140,0.023445,-0.034752,-0.022245,0.034196,-0.042503,-0.026666,0.019926,0.010778,0.007835,0.033967,0.033991,0.030237,0.026261};
  parameter real W2120[0:249] = {0.023649,-0.045588,-0.007732,0.020857,0.023456,0.059218,0.022139,-0.035066,-0.014913,-0.035604,-0.021900,0.016110,0.049200,-0.032759,0.021791,0.047953,-0.033381,-0.018007,0.026258,-0.047870,0.001668,0.027760,-0.000120,0.029354,-0.049295,-0.042613,-0.050912,0.015395,0.018125,-0.032821,-0.059386,0.021285,-0.058516,0.015730,0.012228,0.036861,0.030166,-0.050449,-0.003374,-0.024481,-0.050986,-0.061527,0.034463,0.039916,0.027938,-0.018649,0.011019,-0.052343,0.047931,0.000374,0.059960,-0.059073,-0.023198,0.021596,-0.046253,0.054546,0.030279,-0.064361,-0.010893,0.055165,0.048965,-0.027577,0.014817,0.047938,0.042501,-0.027990,-0.058409,-0.037679,0.028028,0.008519,-0.000873,-0.021952,-0.013285,0.025735,0.058984,-0.056248,-0.018555,0.056116,0.036577,0.017047,0.042078,-0.055614,0.043389,-0.005323,0.024832,-0.033104,-0.010798,0.032679,-0.056966,0.030016,-0.004447,-0.044461,0.007612,-0.028528,0.059804,-0.006235,-0.006884,0.035111,-0.028206,-0.003500,-0.012103,-0.018475,-0.055703,-0.058725,0.035419,-0.041672,0.031615,-0.025666,0.002781,0.043167,-0.021742,-0.012778,-0.045423,0.006362,-0.023410,-0.050486,-0.022061,0.043234,-0.021709,-0.020725,-0.055689,-0.015891,0.008599,0.025985,-0.024166,-0.048240,-0.062435,-0.006812,-0.001440,0.061749,0.002942,-0.047872,0.054962,-0.035010,-0.036329,0.003691,-0.005479,-0.010338,-0.036310,0.037186,-0.001442,0.022169,0.036119,0.030884,0.007216,-0.044109,-0.007155,0.035576,0.028061,0.042254,-0.000671,-0.054339,0.040745,-0.041650,0.001773,-0.049836,0.014617,-0.006957,-0.058304,0.009424,-0.056564,0.004361,0.031902,-0.009421,0.060925,0.031838,-0.004848,-0.015718,0.028264,0.010195,0.053510,-0.016717,0.006490,-0.042438,-0.048080,0.016523,-0.014179,0.060777,0.034908,-0.068370,-0.063303,-0.045941,0.012296,-0.060815,0.049010,-0.009503,-0.067407,0.038720,-0.065470,-0.028029,0.045638,-0.059579,-0.037840,-0.027445,-0.050899,-0.013458,0.041766,-0.049040,-0.032153,-0.017923,-0.014148,-0.039530,-0.006150,0.051420,-0.018767,-0.048513,-0.054956,0.044889,0.042495,-0.015562,-0.045879,0.003875,0.049137,0.066437,0.052668,-0.020828,-0.046230,-0.036745,-0.002830,-0.032838,0.042015,-0.026820,-0.020925,0.040224,-0.064674,0.001547,0.007625,0.017081,-0.015041,-0.038041,-0.016434,0.011540,-0.008366,-0.013229,0.054134,0.057496,0.049915,0.025140,-0.010617,0.022221,-0.041844,0.062924,0.035444,-0.061107,0.048882,-0.038480,-0.003799,0.004622,0.022986,0.060636};
  parameter real W2121[0:249] = {-0.033671,-0.060143,0.005139,-0.052763,0.018501,-0.053739,0.020466,0.035731,-0.051679,-0.024822,0.042698,-0.023563,-0.034966,-0.060719,-0.044477,-0.029858,0.030397,0.042655,0.050270,-0.014102,0.015605,-0.043444,0.015687,0.054180,-0.055714,0.010650,0.002691,0.047563,0.010044,0.065827,0.034448,-0.053111,0.043360,-0.035292,-0.038214,-0.004675,-0.045111,-0.028597,0.045137,-0.053346,-0.057226,0.028309,-0.031469,0.055382,-0.015312,0.010789,0.013230,-0.037085,0.013418,0.057521,-0.008616,-0.038787,0.028493,0.039066,-0.029415,0.032792,0.060642,0.043335,-0.005309,0.060127,-0.041200,0.028740,-0.064285,0.055965,-0.032284,-0.013458,0.032737,-0.045137,0.010116,-0.004411,0.020838,-0.022830,-0.040797,-0.054096,-0.026878,0.063100,-0.040721,0.040958,-0.012088,-0.049762,0.009025,-0.054069,-0.001172,-0.049656,0.024036,0.020272,0.054714,-0.031733,-0.034600,-0.032503,0.005732,0.052581,0.000529,-0.028538,-0.050371,-0.032789,0.031781,0.032196,-0.056153,-0.054064,-0.003949,-0.058350,-0.064017,-0.044295,0.062763,0.043879,0.038181,-0.005809,0.054691,0.041577,0.029382,-0.004994,-0.041205,-0.045899,-0.028630,-0.024748,0.025601,-0.065787,-0.056538,0.011942,0.031562,0.047425,0.069327,0.054888,0.056574,-0.048127,-0.049329,0.002694,-0.037966,-0.063947,-0.054748,0.029234,-0.026778,0.037565,-0.025306,-0.020341,0.066767,-0.026371,0.046077,0.030081,0.000034,-0.052560,0.017237,-0.055375,-0.035820,0.000036,0.055155,-0.050238,-0.044919,-0.063585,0.041247,0.010362,0.018405,0.021709,-0.048757,-0.039281,0.040441,-0.001479,0.043415,0.010004,-0.042678,0.035769,0.013282,0.021713,0.050853,0.038325,0.045642,-0.022787,0.017253,-0.014459,0.025942,-0.043293,-0.027924,-0.047194,-0.021022,-0.039513,-0.000714,-0.028445,0.034868,0.003519,-0.003217,-0.037870,-0.034063,0.030159,-0.062368,-0.004333,0.060063,0.037968,-0.022477,-0.034714,-0.002389,-0.063161,0.005573,0.027451,0.056398,0.058688,0.000235,-0.003986,0.010036,0.045853,0.003969,-0.035381,-0.027433,-0.045902,-0.008601,0.002649,-0.035331,0.009813,-0.058321,0.016478,-0.067348,-0.038971,-0.003911,-0.000660,-0.034154,-0.049069,-0.052008,-0.031795,-0.055298,-0.000247,-0.046782,-0.031918,-0.048108,-0.059668,0.047331,-0.008051,0.012873,-0.028027,-0.029128,0.027000,0.004735,-0.015879,0.064324,-0.061151,0.031012,-0.044289,-0.047723,-0.038983,-0.017375,-0.030577,0.024699,0.049231,-0.043111,0.005664,-0.046184,-0.030047,-0.036409,-0.011243,0.035518,-0.050559};
  parameter real W2122[0:249] = {-0.026752,0.058791,-0.057807,-0.033080,0.043018,0.038197,-0.059104,0.021187,0.045575,0.037028,-0.009956,0.031120,0.051038,-0.002305,-0.056428,-0.057089,0.032768,-0.066091,-0.024138,-0.029644,-0.006763,-0.060374,-0.037700,-0.014695,0.060377,-0.020074,-0.030643,-0.058802,0.029311,0.063711,-0.050181,0.023075,-0.007634,0.022252,0.001375,-0.005650,-0.017711,-0.041801,-0.003584,-0.038748,-0.012032,0.026306,-0.023350,-0.030258,0.038267,0.043858,-0.019187,-0.014896,-0.041228,0.029728,0.036737,0.035437,0.024671,-0.021706,0.007149,0.030043,0.004207,-0.015521,0.054223,-0.011282,-0.057082,-0.042531,-0.007977,-0.033098,-0.045858,0.051234,0.045679,-0.029829,-0.055728,-0.024706,0.018912,-0.036055,0.055523,-0.017146,0.019573,-0.036135,-0.042597,0.015460,0.015532,-0.048495,-0.065383,-0.049611,-0.008629,-0.025492,-0.021002,0.049826,0.008773,0.016849,-0.058886,-0.063170,-0.050388,-0.040897,-0.042999,0.004551,0.048357,-0.004540,-0.042511,-0.054402,0.042344,0.052298,0.036708,0.005604,0.039777,-0.018678,0.020669,-0.001520,-0.009924,-0.057417,-0.056387,0.004669,0.017244,-0.004459,0.059071,-0.012918,0.057053,0.003415,0.054266,0.011297,-0.017578,-0.040699,0.041709,0.034224,0.009289,-0.007832,-0.039709,0.049747,0.003633,-0.065167,0.011480,-0.008511,0.032619,0.035850,-0.056756,-0.057124,0.048124,0.015722,0.001221,0.048825,0.000636,-0.018811,0.036451,0.037122,-0.050773,0.025362,0.043696,0.006649,-0.044143,-0.059929,0.032164,0.019251,-0.057911,-0.019722,-0.039603,0.051483,0.028839,-0.005694,-0.027458,0.008553,0.006665,-0.001781,-0.034026,-0.013990,0.023279,0.054223,-0.038990,-0.064009,0.043609,-0.033419,0.029828,-0.012807,-0.043060,0.022862,0.001605,-0.047844,0.056395,0.007445,-0.062133,-0.014974,-0.060274,-0.011299,-0.038765,-0.036728,0.005822,-0.048186,-0.011343,0.014804,-0.013659,-0.045685,-0.058709,0.034716,0.021039,-0.024712,-0.005999,-0.033963,-0.007400,0.026582,-0.058593,-0.012604,0.044870,0.043654,0.060998,-0.028593,0.006616,-0.044598,-0.061274,0.013604,-0.044923,-0.060625,-0.011795,0.026135,-0.046759,0.030801,0.028497,0.054452,0.030298,0.028800,-0.054745,-0.019336,-0.051889,0.038558,0.018705,0.056308,-0.023162,0.030984,0.024532,0.006812,0.006043,0.038320,0.016239,0.011483,-0.022554,-0.056081,-0.012655,-0.027139,-0.005842,0.022853,-0.050045,-0.043365,-0.014065,-0.041868,-0.005565,-0.047977,-0.012333,-0.040990,0.033911,-0.039317,0.061445,-0.006521,0.024285,-0.035073};
  parameter real W2123[0:249] = {-0.025189,-0.033273,-0.046226,0.023576,-0.019473,0.039605,0.019509,0.026184,-0.045046,-0.063419,0.044531,0.024756,0.012927,-0.050469,-0.038949,-0.026477,0.004267,0.011024,0.055020,-0.045723,-0.027859,-0.039966,-0.003160,-0.059033,0.052883,0.017337,0.006745,0.035660,0.019448,-0.005588,0.022356,-0.060415,-0.031449,0.022677,0.066999,-0.011474,0.022932,-0.049849,0.062470,-0.025346,-0.035687,0.035290,-0.004673,0.036705,0.028291,-0.027703,-0.061487,0.023821,0.021893,-0.009052,-0.072710,-0.004206,-0.006362,0.004352,-0.009593,-0.005363,-0.035684,0.019678,-0.006728,0.012111,-0.036829,0.009112,0.001502,-0.049420,-0.035940,0.043035,-0.043697,-0.013339,-0.036611,-0.036440,0.011061,0.058728,0.021441,-0.021650,-0.026889,0.074869,-0.032550,0.057744,0.002807,0.032988,0.036798,0.030197,0.066744,0.102624,0.001030,0.048195,-0.030955,-0.075511,-0.001136,-0.017712,-0.050724,0.008475,-0.028205,0.038454,0.000401,-0.029016,-0.015546,0.035467,0.018144,0.007483,0.022059,0.011608,-0.006080,-0.017403,-0.033154,0.002055,-0.084180,0.021271,-0.042055,0.018733,-0.004627,0.033359,0.029721,0.012238,-0.026559,-0.001672,-0.061794,-0.003308,-0.055495,-0.044640,0.067962,0.031839,0.006284,-0.060700,-0.072471,0.017429,0.030988,0.068347,0.058706,0.013845,0.020447,0.048520,0.003576,0.008929,0.039715,-0.039957,0.035134,0.056477,0.039077,0.015394,-0.024084,0.056921,-0.005943,-0.061607,0.005689,0.031737,-0.020751,0.030320,0.010924,-0.032970,0.032855,-0.048332,-0.005351,-0.064758,-0.064626,-0.046809,0.016666,-0.036746,-0.008067,0.015177,0.027728,0.027645,0.065012,0.039728,-0.053534,-0.061965,0.011277,-0.026911,-0.034011,0.009695,-0.032452,-0.018487,-0.052793,-0.032208,-0.032156,-0.058177,-0.054020,-0.037920,0.034398,0.055929,0.062350,0.029580,0.006363,-0.029753,-0.024538,-0.002986,-0.018398,0.033729,-0.006770,0.044016,-0.046470,-0.021615,0.050058,0.077283,0.082951,0.031623,-0.002296,0.013117,0.011138,0.018680,-0.028844,0.045207,0.045539,-0.044522,-0.005165,-0.054921,0.027338,0.039559,0.005481,-0.053109,0.011532,-0.044483,-0.016650,0.037927,0.081093,-0.045508,-0.038554,0.001700,-0.006550,-0.031942,0.001973,-0.003132,-0.040171,-0.008655,0.048496,-0.055612,0.037452,0.056754,-0.047920,0.003477,0.050878,0.002469,-0.026804,0.065037,0.030736,0.014254,-0.057576,-0.066137,0.033377,-0.020536,-0.039851,-0.018956,-0.061203,-0.016053,0.039369,0.039054,0.003521,0.066599,0.035567,0.042942};
  parameter real W2124[0:249] = {-0.039953,0.007142,-0.006906,0.057171,0.025660,-0.025094,0.049150,0.040192,-0.019471,0.068634,-0.012743,0.023466,0.042460,0.000510,-0.037772,0.053426,-0.029239,0.039945,0.018382,0.043181,0.026140,0.008388,-0.031327,-0.028508,-0.030623,0.020075,0.008534,0.001390,0.019878,0.025464,0.038735,0.059347,-0.044758,0.055495,-0.038137,0.056198,-0.041076,-0.018534,0.051125,0.047645,0.060827,0.038550,0.037838,-0.000394,0.056364,0.001105,0.018373,0.050424,0.045760,-0.033522,-0.019947,-0.031244,0.034317,-0.026053,-0.030239,-0.056988,0.025419,0.018791,0.056884,0.054782,-0.008558,-0.007391,-0.005438,-0.004136,0.046158,0.065954,0.029247,0.025697,0.017249,0.035263,0.000726,0.018755,-0.048546,-0.052640,0.012400,-0.071645,0.001995,0.044435,0.061632,-0.002500,-0.050776,0.055463,-0.064363,-0.064285,0.009049,-0.005182,-0.020255,0.049380,-0.018022,0.043974,-0.011733,0.047212,-0.025669,-0.013812,0.014445,-0.049985,0.022954,-0.001677,-0.018106,0.052740,0.003119,0.023162,-0.044440,-0.023218,0.047782,-0.044953,0.005363,0.056038,-0.003045,0.053992,-0.041056,-0.039659,0.011166,-0.020981,0.067425,-0.002453,0.028181,0.028761,0.012659,0.027964,0.037277,-0.020545,0.023138,-0.043768,0.024258,0.056152,-0.052665,-0.046717,-0.000118,0.052394,0.047214,0.047527,0.011443,-0.030706,0.034244,0.025316,0.013768,0.009537,0.028074,0.067052,0.036256,0.011935,-0.001093,0.047678,-0.041995,-0.042616,-0.025510,0.056010,-0.000300,0.055413,0.036662,0.054416,-0.049823,0.062349,-0.025638,0.006836,0.051034,0.047503,-0.030542,-0.041836,0.004905,-0.029359,0.051518,0.008403,-0.028536,0.073882,0.037235,-0.008357,-0.041317,0.035827,-0.002620,-0.034720,-0.038352,-0.023852,0.018494,0.023383,0.045332,0.050004,-0.051311,-0.041982,0.065686,0.024120,-0.057803,-0.054206,0.022303,-0.011345,-0.049063,0.005603,-0.056876,-0.040998,-0.021393,0.038788,-0.032173,-0.031231,0.003029,0.052579,0.021127,-0.037144,-0.056100,-0.040079,0.045269,0.019645,0.030753,0.058727,-0.030347,-0.050937,-0.023821,0.040025,-0.037172,0.034457,-0.041233,0.036423,-0.057393,0.041624,-0.022578,-0.047217,0.035903,0.003234,0.011579,0.044717,0.061650,-0.035338,0.020975,-0.050083,-0.021311,-0.042513,0.058441,0.037599,-0.045735,-0.043364,0.018226,0.030450,0.004904,-0.040340,-0.040667,0.036470,0.030919,-0.002210,0.056328,0.039349,-0.019145,-0.009737,-0.056645,0.050841,0.048466,0.053717,-0.017927,-0.039402,0.046322,-0.054967};
  parameter real W2125[0:249] = {0.048825,-0.044036,0.048814,0.055265,0.049474,-0.061388,-0.012361,0.025040,0.000913,-0.035702,-0.029434,0.011957,0.045260,0.008543,-0.064468,-0.009116,0.051462,0.043254,0.060236,0.061817,0.003390,0.025749,-0.053671,0.012438,-0.003987,-0.032479,0.042917,-0.060373,0.010243,-0.045117,-0.047382,-0.003784,-0.030415,-0.030026,0.020466,0.001448,-0.048577,0.026837,-0.017951,0.059217,-0.047419,-0.039486,-0.020941,0.022775,-0.035839,0.050348,0.025145,0.000295,0.046576,-0.012944,-0.019122,-0.024470,0.039900,0.040150,0.004319,-0.016487,-0.031267,0.031060,0.024768,-0.057547,-0.060956,0.013670,0.007308,-0.009686,-0.042870,0.013133,0.061956,-0.049156,0.029769,0.019428,0.029167,-0.014837,-0.008276,0.023945,-0.071298,-0.006220,0.009089,-0.015151,-0.028701,-0.013290,-0.026669,0.009042,-0.011224,0.060528,-0.060534,0.008265,-0.005793,-0.015747,0.035657,0.039665,0.021000,-0.039447,0.065081,0.005638,-0.005205,0.033865,-0.006261,-0.019331,-0.001431,0.014201,0.026166,-0.032564,0.035245,-0.019729,-0.028204,0.008867,0.012980,-0.018432,-0.023857,-0.003742,0.045116,0.042794,-0.030151,-0.007759,0.047864,-0.015561,-0.045361,-0.062574,0.040271,0.005635,0.065556,-0.037079,0.015861,-0.013964,0.047430,-0.011922,0.000607,-0.062456,0.063325,0.014367,0.054293,0.028169,-0.035162,0.059934,-0.017547,0.043472,-0.014331,-0.042853,-0.016445,0.007938,0.010506,-0.050367,-0.006562,-0.033191,0.046906,0.058459,-0.022785,-0.034909,0.040860,-0.064042,0.036055,-0.067496,0.041375,-0.029574,-0.059303,0.011051,-0.005013,0.005523,-0.019059,-0.004896,-0.049195,0.031100,-0.024312,-0.026120,0.012014,-0.043339,-0.015083,0.041121,0.005335,-0.006741,0.017215,-0.017538,0.033916,0.037683,-0.002038,-0.020083,-0.021520,-0.001360,0.006147,-0.033461,-0.039240,-0.057228,0.000810,0.035188,0.007027,0.015567,-0.035800,0.003079,0.035277,-0.017519,-0.055969,0.061833,-0.045893,-0.011154,0.036958,-0.013264,-0.040012,0.034378,-0.051686,0.037061,0.052362,-0.023288,-0.015770,-0.049490,0.061549,-0.021318,0.052716,0.062193,0.041148,-0.057733,-0.031467,-0.030824,-0.010742,0.050847,0.032033,0.029727,0.060202,-0.059450,-0.046687,0.003925,-0.039764,0.058610,-0.029896,-0.042828,-0.001260,0.003947,0.055922,-0.035906,-0.027165,0.046836,-0.060032,-0.035999,-0.044052,0.013615,-0.023099,-0.007354,-0.036075,0.050629,0.035233,0.036146,-0.054498,0.044437,0.007925,0.000348,-0.057108,-0.005341,-0.045649,0.012705,0.041637,0.023725};
  parameter real W2126[0:249] = {0.043509,-0.027057,-0.021516,0.026431,-0.027186,-0.063805,0.052810,-0.064868,0.061655,-0.054207,-0.057443,-0.001850,0.039525,0.002969,-0.006896,-0.021424,0.051504,-0.042982,-0.054275,-0.011910,0.037738,-0.023820,0.039428,0.036808,-0.046255,0.051806,-0.038415,-0.013788,-0.023203,-0.060200,-0.007212,0.000579,-0.057467,-0.004600,-0.045945,-0.056430,-0.059004,-0.017672,-0.018630,0.056592,-0.056162,0.045790,0.008464,-0.006838,-0.004153,-0.010412,-0.005046,0.055830,-0.010744,0.001330,-0.029203,-0.013608,0.030220,0.031776,0.035504,0.057722,-0.014029,0.003162,-0.017243,-0.029690,-0.040579,-0.012934,-0.029437,-0.055346,0.051754,-0.052799,0.035491,0.041259,-0.008884,0.027212,0.060758,0.044387,-0.048374,0.000261,-0.030637,0.023336,0.050984,0.050424,-0.043217,0.024472,-0.009362,-0.006554,-0.016139,0.035881,0.023963,-0.002171,-0.055688,-0.055095,-0.046969,0.038240,0.033291,0.052050,0.058734,0.026896,-0.042706,-0.060992,-0.022536,0.040028,0.004214,0.034970,0.008917,0.043991,-0.000156,-0.018306,0.000209,0.000872,-0.001620,-0.027690,-0.058922,-0.049120,0.049929,0.046932,-0.021012,-0.042030,0.059950,-0.048497,0.032009,-0.048612,0.031734,-0.037797,0.038662,0.003687,-0.057440,0.037936,0.056149,-0.030044,-0.019396,0.051679,-0.037123,-0.052822,-0.013254,-0.005698,0.061460,-0.016459,0.022575,-0.021751,0.059724,-0.028656,-0.067591,0.047984,0.014379,0.026422,-0.036579,0.010507,0.018009,0.024667,0.005246,0.024505,-0.062205,-0.036239,-0.002755,0.045202,0.005863,-0.016343,-0.001539,0.054087,-0.034255,0.066449,-0.035306,0.011141,0.055167,-0.026699,-0.020720,-0.060679,0.061350,0.044636,-0.012701,0.051118,-0.035504,-0.060695,-0.052997,0.058933,0.002150,-0.062350,-0.002632,0.056915,-0.052247,0.020129,-0.054806,0.050606,-0.022367,0.030429,0.017354,-0.035152,-0.058072,-0.003807,0.051339,0.010191,-0.041115,-0.039224,-0.005546,0.059490,-0.047048,0.003574,-0.040060,0.032019,0.035291,-0.054623,0.046731,-0.042613,0.026461,0.042606,-0.035718,0.013769,-0.000284,-0.002389,-0.015846,-0.041286,-0.003152,0.046750,0.025430,0.011690,-0.008769,-0.013972,0.027256,-0.041953,0.044991,-0.059421,0.019689,-0.011764,0.022379,0.036101,-0.054654,-0.029465,-0.000588,-0.021784,-0.019107,0.042167,0.044245,0.015174,0.038472,0.058982,0.042110,0.027740,-0.027945,0.011961,0.053562,0.035209,0.022188,0.036394,-0.020895,0.035587,0.040496,-0.004615,-0.006285,-0.037856,0.011125,-0.058673,-0.057892,0.002945};
  parameter real W2127[0:249] = {-0.031278,-0.046921,0.036955,-0.009192,-0.011003,-0.041875,0.045307,0.066116,0.001343,0.007699,0.010249,-0.054485,-0.026563,-0.021480,-0.031215,0.021270,0.044238,-0.029302,0.010441,-0.006889,0.013479,0.025809,0.022939,0.048638,0.024166,0.000536,-0.004988,0.033558,0.015709,-0.053071,0.062463,-0.026201,0.019837,-0.023488,-0.043668,-0.015022,0.010027,-0.055243,-0.031579,0.021207,0.028372,-0.001210,0.020540,-0.017866,0.017488,0.017156,-0.014145,0.004988,0.000757,-0.014355,-0.028488,-0.013919,0.018806,-0.026868,0.043151,-0.043229,-0.002816,0.006423,0.009929,-0.001503,0.045759,0.044971,0.065489,-0.056261,0.021969,-0.021396,-0.062472,-0.053166,-0.051678,-0.056786,0.042242,-0.031096,0.035241,0.051601,-0.065320,0.003079,-0.056093,0.025816,0.022905,0.009068,0.029558,-0.020955,0.050951,0.009197,-0.033323,-0.002864,0.005022,0.000972,-0.016842,0.050767,0.069668,-0.019871,-0.068483,0.054035,-0.032350,0.010748,-0.058863,0.033729,-0.019377,-0.016973,0.024670,-0.062412,-0.046734,0.014349,-0.041604,-0.025022,-0.024002,-0.059814,-0.010647,-0.038607,-0.040025,0.003749,0.049195,-0.015657,-0.030301,0.047929,0.005501,-0.055228,-0.034078,0.060054,-0.017966,-0.016691,0.023077,0.016108,0.056389,-0.042798,0.003347,0.051329,0.020061,0.032481,-0.026078,0.066920,-0.001533,-0.042864,-0.033191,-0.040296,-0.018110,0.001531,-0.014935,0.028417,0.025853,-0.043859,0.033914,0.029951,0.012605,0.057223,-0.028717,0.008708,0.031470,0.010149,0.037196,0.029859,0.073879,0.026647,0.046477,-0.003585,0.001935,0.066553,0.022694,0.038367,-0.000004,0.059075,0.071865,0.023178,-0.060339,0.039651,-0.026393,0.018952,-0.018780,0.007707,-0.028134,-0.033005,0.047554,-0.007789,0.001894,0.008639,-0.014812,0.053241,0.023320,-0.044791,-0.024499,-0.031558,0.056538,0.007728,-0.003129,-0.038057,0.037986,0.040956,0.059924,0.033271,0.023303,0.053491,0.004650,0.057283,0.049543,-0.020356,0.042623,0.057096,0.028795,-0.039823,0.005364,-0.022077,0.021850,0.048762,-0.004758,0.007379,0.050758,-0.014264,0.040730,0.061482,0.059158,0.052498,0.012376,-0.061895,-0.031937,-0.019174,-0.050235,-0.046262,0.008314,-0.047394,0.027932,0.029144,-0.056424,0.035845,-0.026822,0.007176,-0.044012,-0.050949,0.061432,-0.037333,0.008001,-0.008344,-0.005985,-0.005978,0.028878,-0.015307,-0.008561,0.053565,0.037609,-0.066013,-0.027373,0.037546,-0.028491,0.021326,-0.057086,-0.040639,0.045189,-0.033808,-0.010348,0.030607};
  parameter real W2128[0:249] = {0.057532,-0.023473,-0.029796,0.048351,-0.007383,-0.008023,-0.004044,0.000970,-0.059558,-0.038915,-0.035415,0.051955,0.016171,0.007836,-0.044645,0.047063,0.022947,0.028021,0.067040,0.028635,0.057430,0.034976,0.065031,-0.018921,-0.019776,0.009347,0.010289,-0.036516,-0.013952,0.019431,-0.010472,0.058661,-0.025685,-0.039028,-0.013419,0.009504,-0.020061,0.053323,-0.026396,0.055553,-0.024258,0.043734,0.031983,0.034826,0.062991,0.054618,-0.050040,-0.027816,0.020695,-0.053708,0.003546,0.019652,-0.019066,0.029373,0.007832,0.027940,-0.036153,0.030223,0.023362,0.027942,-0.041226,0.059876,0.045373,0.032462,-0.019565,0.059870,-0.002635,-0.008752,0.014160,0.003940,-0.062346,-0.034736,-0.048376,0.026727,-0.052262,-0.018449,-0.003095,0.034278,-0.003230,-0.021439,-0.032466,-0.023501,-0.049600,-0.048258,0.063170,0.038295,0.050607,0.031932,0.004169,-0.010085,0.006436,-0.021288,-0.031618,0.014060,0.023828,-0.047700,-0.008580,-0.022190,0.060165,0.056914,-0.049295,-0.033470,-0.019986,-0.057136,0.050948,-0.012512,-0.006916,-0.027998,-0.021563,-0.061548,-0.019846,-0.030524,-0.012581,0.031044,0.037789,-0.014237,-0.001565,-0.055080,-0.060176,-0.021940,0.045135,-0.017360,0.049479,-0.035528,-0.043675,0.017798,-0.029543,-0.045136,-0.039830,-0.007220,-0.025447,0.055227,0.057681,0.017870,0.059845,-0.006630,-0.030392,-0.012447,-0.034046,-0.013941,-0.053330,0.004376,0.003002,-0.050059,-0.055028,0.042730,-0.026232,-0.030445,0.029507,-0.057962,0.033058,0.013013,0.019132,-0.037756,0.018755,-0.056191,-0.051238,-0.044685,0.046625,-0.031957,-0.050384,0.048885,-0.028091,-0.035179,0.011052,0.016133,-0.025022,-0.013500,-0.056115,-0.007604,-0.050557,0.039194,-0.058368,0.048460,0.003771,0.003932,0.041194,0.033404,0.044137,0.000610,0.004901,-0.033901,0.011274,0.046747,0.030306,-0.008870,0.006181,-0.009524,-0.028467,-0.048681,0.035437,-0.054710,0.059214,-0.040819,-0.050246,0.031645,0.012480,-0.029935,-0.023862,0.010309,0.027187,-0.026289,0.016679,-0.005275,0.053779,-0.001373,-0.049277,0.022492,0.007899,0.022462,-0.051671,0.032420,-0.005501,-0.036196,0.047064,0.043097,0.018875,0.041517,-0.065182,0.052229,-0.054171,0.012130,0.040884,0.012288,0.057040,-0.024986,0.060550,-0.041761,0.022224,-0.017091,0.007251,0.046569,0.032295,-0.047108,-0.022108,-0.056905,-0.043625,0.013352,0.023234,-0.027440,0.017515,-0.007523,-0.024968,0.007197,0.032003,-0.012158,0.007686,0.027208,-0.026628,-0.031753};
  parameter real W2129[0:249] = {-0.046795,-0.040187,0.061768,0.040618,0.035946,-0.026881,-0.007465,-0.033537,0.043563,0.013608,-0.017890,0.018804,0.004889,-0.055131,0.037894,0.013849,0.031955,-0.011116,-0.045663,0.006356,-0.008591,0.000917,0.037662,0.038107,-0.052108,-0.039794,0.043306,0.001137,-0.053333,0.051113,-0.055188,-0.028767,0.022171,0.018808,0.043355,-0.055187,-0.007649,0.055513,0.021119,-0.008302,0.030829,-0.007899,-0.020743,-0.029283,0.048154,0.034156,-0.012815,0.042096,-0.064484,0.033414,0.044236,0.011324,-0.020551,0.036429,-0.011689,0.054293,0.034390,-0.008906,-0.043612,-0.043828,-0.003602,0.030847,0.049866,0.040792,0.045009,-0.018152,0.002324,-0.026770,0.013859,-0.014978,-0.006849,0.023475,0.005535,-0.043862,0.057475,0.058831,-0.053902,-0.001860,0.010592,0.021505,-0.047809,-0.033920,0.036425,-0.065137,-0.059120,0.046934,0.015696,-0.036325,-0.047087,-0.062031,0.030077,0.001491,0.017649,-0.012370,-0.030353,-0.033688,-0.060135,0.041216,-0.038239,0.052135,-0.018050,0.061554,-0.019961,0.048715,0.039109,-0.001479,0.003059,-0.043370,-0.047973,0.027470,-0.029654,0.058193,-0.037014,-0.014842,0.007769,0.055162,0.004854,-0.056212,0.015648,0.061445,0.047044,-0.061438,-0.025727,-0.017302,-0.057564,-0.057640,0.028272,-0.041232,-0.047583,0.002457,-0.027657,0.063194,0.030856,-0.046240,-0.065293,0.045564,-0.020534,-0.053412,-0.050236,-0.004922,0.028340,0.004018,0.013460,0.059906,0.034188,0.010172,-0.063021,-0.017126,-0.030265,0.030866,0.060492,-0.020972,0.001849,0.031242,-0.057724,0.046757,0.002085,-0.031086,-0.014473,-0.041492,0.056421,-0.002484,-0.001828,-0.032774,0.039911,-0.006736,0.047591,0.018820,0.029422,0.059563,0.038882,0.052899,-0.029405,0.008419,0.014358,-0.025624,-0.049334,0.030968,0.057490,-0.063595,0.038644,-0.001797,0.006384,0.043192,0.045399,0.051544,-0.005472,-0.027335,-0.008499,0.047992,-0.054013,0.009969,-0.036809,-0.000692,-0.043565,-0.021344,0.044995,-0.000609,0.061068,-0.054208,0.028041,0.008960,0.029684,-0.024638,-0.028787,0.010101,0.008952,-0.035513,-0.022689,0.021877,0.040893,0.053228,-0.006097,0.045036,0.028807,0.001017,0.009844,-0.025689,-0.019746,-0.009686,-0.050760,-0.014590,0.037691,-0.009256,0.010432,-0.028960,0.021883,0.004122,0.017373,0.032919,-0.006986,-0.029249,-0.061360,-0.024692,0.041146,-0.019879,-0.039161,-0.059659,-0.047037,-0.021248,-0.008414,0.033567,0.060089,-0.047559,0.009964,0.023232,-0.004426,0.053514,0.013619,0.042564};
  parameter real W2130[0:249] = {0.003865,-0.066224,-0.029471,-0.044321,0.052799,0.053465,-0.046995,-0.022120,-0.033211,0.026054,0.016259,-0.010173,-0.027409,0.016556,-0.048326,0.047047,0.017581,-0.064135,0.053055,0.016009,0.030440,0.011579,0.053823,0.031691,0.054120,-0.025870,-0.026328,0.007655,0.008055,0.033918,-0.020719,-0.036317,0.035335,0.012273,-0.009433,0.044858,0.046906,0.017028,-0.050299,0.034648,-0.048203,0.036154,0.050513,-0.028603,0.036085,0.000823,-0.013531,-0.026524,0.053282,-0.035317,0.020669,0.010903,-0.002009,0.035413,-0.032591,0.060203,-0.018656,0.054156,-0.028370,-0.015308,0.048572,-0.030148,0.063970,-0.039770,-0.062053,0.004010,0.025634,-0.056563,-0.028013,-0.001969,0.007004,-0.023053,0.046392,-0.010103,-0.006811,-0.013212,-0.023744,0.006270,-0.021379,0.036809,0.046159,0.016595,-0.033242,0.019560,0.002485,-0.056932,-0.020968,0.010059,0.048642,0.020722,-0.025654,-0.068382,0.017154,0.072888,0.017251,0.051775,-0.059100,0.053708,-0.037926,0.033377,0.017573,0.013958,0.058516,0.033086,0.060510,0.016429,0.044001,-0.049454,0.001694,-0.017897,0.030495,0.007991,0.046360,0.010706,-0.001141,-0.042797,-0.029581,0.045527,0.039800,-0.041010,-0.016030,-0.004116,-0.053693,-0.019837,0.031588,0.063175,-0.013076,0.045271,-0.011833,0.016479,0.058202,0.061103,-0.066362,-0.061350,-0.040355,-0.022495,0.024251,-0.017307,-0.019429,0.031630,-0.067272,0.003757,0.025823,-0.018672,-0.004459,0.009591,0.028779,0.069684,0.008917,0.002869,0.055859,-0.035763,0.056293,-0.041051,-0.053364,0.053900,0.016177,0.053291,0.004948,-0.051245,-0.057644,0.006644,0.058343,0.013028,-0.011966,0.027996,0.031525,0.063022,-0.049770,0.028872,-0.009264,0.056755,0.043351,0.030666,0.012903,0.024219,0.037260,-0.007523,-0.058281,0.033417,0.053278,0.042240,0.001968,0.037472,0.006362,-0.034091,0.042314,0.025018,0.068542,0.030028,0.018117,0.024125,0.002344,0.032526,-0.011016,0.049158,-0.052384,-0.034084,0.011145,0.016943,0.007642,0.001994,-0.039574,0.010412,0.036803,-0.022425,0.043517,-0.051459,0.036296,-0.011720,-0.043041,0.048098,0.017786,-0.049939,-0.039552,-0.028389,0.015352,-0.023087,-0.040113,0.050811,-0.054975,0.019592,0.052166,-0.050529,-0.046665,-0.024395,-0.001293,-0.028760,0.016095,0.046598,0.045849,-0.051860,-0.060525,-0.052338,0.015177,-0.027341,-0.045673,-0.024569,-0.046914,-0.003362,-0.064270,0.028193,0.022132,0.031500,-0.020882,0.050429,0.036699,-0.042375,-0.049883,-0.060891};
  parameter real W2131[0:249] = {0.049388,-0.046958,0.004288,0.060585,-0.018098,0.003965,-0.039224,0.013654,-0.008287,0.023755,0.049166,0.019880,0.009071,-0.035155,0.030969,0.027105,-0.022037,0.064578,-0.038221,0.038837,0.025478,0.034624,-0.049526,-0.022817,-0.019153,-0.012964,-0.051288,0.023433,0.017815,0.036379,0.017495,-0.059442,0.060455,0.046116,0.048704,-0.019164,0.034653,0.017949,-0.012197,0.039556,-0.019566,-0.040287,-0.018069,0.002748,0.031386,-0.004050,-0.022904,0.059455,-0.023878,0.010212,0.023040,-0.050498,-0.014122,-0.046187,-0.056125,-0.030937,0.017834,0.017887,0.007336,-0.032676,0.059246,0.015638,0.044759,-0.049787,0.015597,0.042826,0.049144,-0.014528,-0.049661,0.042579,-0.032506,-0.042979,0.050844,0.058632,-0.039202,-0.010914,-0.023770,0.050151,0.052985,-0.051246,-0.002340,-0.013897,-0.001687,0.050959,0.016129,-0.042920,0.029322,-0.058870,-0.027890,0.039469,-0.010958,-0.050564,0.062556,0.019355,-0.030025,0.048659,-0.008006,-0.016933,0.049972,0.057193,-0.050063,0.021843,0.006783,0.030458,-0.014821,-0.011764,0.001402,-0.007159,0.008735,0.003980,0.039103,0.061150,0.032850,-0.004988,-0.046891,-0.002759,0.031526,-0.014911,-0.022766,-0.004458,0.029355,-0.063560,-0.030396,0.015123,-0.048667,-0.008193,0.024336,-0.010735,-0.053754,0.021870,0.030079,0.039734,0.041769,-0.004678,0.050463,-0.000319,0.050018,-0.026428,0.058810,0.022653,0.028666,0.023878,-0.040172,-0.013890,0.038833,-0.032478,-0.018693,-0.036709,-0.032159,0.029371,0.036740,-0.001803,0.050388,-0.047096,0.054065,0.035831,-0.020502,-0.046481,-0.021821,0.006630,-0.013202,0.055074,-0.054222,-0.032605,0.049859,-0.058755,-0.027060,0.014941,0.059731,0.010577,0.015518,-0.044494,0.045322,0.005690,-0.003537,0.006076,-0.026362,0.016016,-0.029716,0.018005,0.045701,-0.009964,-0.035627,-0.058071,-0.021766,0.001466,-0.018305,-0.003162,0.039536,0.062327,-0.027785,-0.033595,-0.058398,-0.029042,0.074145,0.039180,-0.004971,-0.020106,-0.045916,0.010825,0.058746,0.039769,0.040023,0.020470,-0.058693,0.007396,-0.008805,0.053819,-0.004058,-0.057625,0.024206,-0.041769,0.016386,0.045880,0.012240,0.040358,-0.053785,-0.028159,-0.014898,0.045413,-0.025313,0.019861,0.058560,-0.011862,-0.004366,0.033734,0.026109,-0.010317,-0.057627,-0.010136,0.036165,-0.057436,-0.050650,-0.008344,0.059951,-0.046057,0.056793,0.049525,-0.031851,-0.022603,-0.003909,0.027771,-0.054638,0.009997,0.051594,0.040845,-0.024491,0.025627,-0.015196,0.061877};
  parameter real W2132[0:249] = {0.047099,0.046959,0.027126,-0.007694,0.002056,-0.058549,-0.046374,-0.045117,-0.035373,0.065198,-0.009940,-0.010795,0.035919,0.000079,0.051622,-0.041439,0.018150,0.062933,0.016960,0.043688,-0.030510,0.041737,0.035905,0.029878,-0.028247,-0.040878,-0.023581,-0.038605,-0.010806,-0.039484,-0.024142,-0.000148,-0.040363,-0.017662,0.041845,-0.023852,0.027944,0.053996,0.048550,-0.000016,0.013283,-0.001124,-0.044633,-0.003277,-0.005605,0.019337,-0.037355,-0.013895,-0.044149,0.056588,-0.011243,0.001408,0.050625,-0.008144,-0.057530,0.001407,0.056585,-0.007246,0.011882,-0.040733,0.018625,0.011545,-0.030895,0.013756,-0.010310,-0.038314,0.023694,-0.038030,0.046857,-0.040386,-0.027398,0.006453,0.007422,0.025619,-0.001439,0.020656,0.065491,0.044899,-0.033210,-0.028238,0.003642,-0.006462,0.060981,0.006979,-0.037287,-0.038331,0.013934,0.026885,0.022351,-0.056293,0.044729,0.011967,-0.021835,-0.052827,0.051606,0.012278,0.020121,-0.034707,-0.056664,0.014578,0.002483,0.031806,-0.047600,-0.035486,-0.041349,0.055861,0.000992,0.060499,0.034150,-0.003388,0.065356,0.000012,-0.005879,-0.003773,-0.043457,-0.049279,-0.004776,-0.000762,0.033580,0.024269,-0.066226,-0.024068,0.052708,-0.032280,0.040371,-0.004323,0.060423,0.020660,0.008561,0.001751,-0.053987,0.046677,-0.028666,0.010428,0.057316,-0.024943,0.018686,-0.046916,0.034561,-0.056741,-0.031181,-0.014168,0.043490,-0.034519,-0.002015,-0.013990,0.043875,-0.053615,-0.001614,0.016702,-0.048604,-0.053731,-0.047481,0.039405,-0.007296,0.058332,0.026124,0.054967,0.007767,-0.055854,-0.040547,0.006634,-0.045932,-0.026829,0.046654,-0.006935,0.013465,0.043755,-0.052667,0.049708,0.003274,0.023670,-0.044115,-0.039280,-0.046547,-0.035512,0.043972,-0.005521,-0.010719,0.043781,0.003365,-0.011972,0.014395,-0.003858,0.038612,-0.055348,-0.057035,-0.037327,0.007756,-0.021018,0.007344,-0.018491,0.003075,0.023819,-0.021257,-0.047628,0.060412,-0.005465,-0.004115,0.011473,0.002983,-0.037675,0.002463,-0.048150,0.037098,0.049711,0.019947,-0.030715,-0.048533,0.018100,0.016245,0.016556,0.036121,0.011377,0.041677,-0.035456,-0.014709,-0.015023,0.040310,0.001028,0.013365,-0.036009,0.052619,-0.043490,0.002221,-0.036959,-0.024115,-0.028842,-0.051801,-0.063943,0.027274,-0.005811,0.039257,-0.032151,0.012853,-0.037970,-0.007211,-0.013441,-0.047197,-0.014867,0.049210,0.016864,0.036973,0.038327,-0.053256,0.016733,-0.002444,0.029697,0.050857,-0.015990};
  parameter real W2133[0:249] = {0.003554,0.044005,0.026204,0.000872,0.025750,0.010056,0.052166,-0.039817,-0.048914,-0.053031,0.015680,-0.011755,0.025977,-0.028417,-0.035275,-0.000947,0.036285,0.000628,-0.003872,0.038891,-0.016870,-0.000123,-0.064105,0.044855,0.051698,0.024171,-0.061129,0.059294,-0.031411,-0.052578,-0.064245,-0.000567,-0.050049,0.011613,-0.032556,-0.018899,-0.020194,-0.031100,-0.064934,0.001571,-0.001241,0.035178,0.050363,-0.031241,-0.027671,-0.030176,-0.001604,0.023734,0.026447,-0.000832,-0.022727,0.055388,-0.063878,-0.034312,-0.055415,0.049851,0.043677,-0.056049,0.008864,-0.046398,-0.042026,0.053354,-0.016593,-0.002321,-0.055889,0.004317,-0.007918,-0.056093,-0.019338,0.018662,0.033250,0.016489,-0.048411,-0.038582,-0.016946,-0.058422,0.018940,-0.030291,-0.062148,0.052887,0.042283,0.007750,0.045133,0.036072,0.003481,-0.051073,-0.012638,0.028514,-0.059223,-0.008257,0.052728,0.021850,0.059435,-0.041425,0.064489,-0.000193,-0.058814,0.050129,-0.024164,0.059599,-0.060309,0.033672,-0.004884,-0.011716,-0.012203,-0.046937,-0.043754,-0.009813,-0.045691,0.022399,-0.009169,-0.033510,0.020914,-0.052102,-0.030966,0.001164,0.041137,-0.048604,0.019883,0.018037,0.013767,-0.052445,0.041919,-0.023393,-0.062178,-0.019691,0.013749,-0.029436,-0.059604,-0.006398,-0.023392,0.000550,0.052884,-0.010660,0.038203,-0.019261,0.010923,-0.025523,0.038646,-0.054886,-0.053937,0.048104,-0.004429,-0.011118,0.050504,-0.024463,-0.008230,0.016914,-0.002358,-0.055316,0.036783,-0.041852,-0.054813,-0.063087,-0.008639,-0.039491,-0.005686,-0.034733,0.006546,0.045570,-0.005830,-0.029089,0.045486,-0.035710,0.062007,0.036759,-0.061070,0.046376,-0.031825,0.027367,0.048618,0.002967,-0.009615,-0.058298,-0.022031,0.043079,-0.009766,-0.025133,-0.046477,-0.019175,0.039410,-0.056561,0.010423,0.015570,0.018897,0.011952,0.015965,-0.052295,-0.013695,-0.018364,0.034265,0.002578,0.006250,0.022600,0.016383,0.017601,0.038688,-0.032143,-0.009572,-0.011903,0.055028,-0.000429,0.026274,-0.024105,0.030924,-0.028658,-0.056356,-0.047390,-0.062537,-0.046358,0.036954,0.054195,0.062677,0.028119,0.055280,-0.057149,0.012694,0.043507,-0.051527,-0.023435,-0.035353,-0.052677,0.032612,0.061214,0.004566,-0.016673,0.020102,0.002887,-0.041215,0.048788,0.003972,0.056554,0.017559,0.027013,-0.054216,0.029889,0.006817,0.025305,0.025008,-0.046257,-0.010988,-0.011307,0.023196,0.057255,-0.020242,0.041775,0.041088,-0.053876,-0.022971,0.054355};
  parameter real W2134[0:249] = {-0.028007,0.036444,0.001072,0.042194,-0.029209,0.034791,0.047268,-0.014769,0.003651,0.019714,-0.003194,0.053395,-0.062486,-0.024474,0.028260,0.001292,-0.008417,0.029105,0.049905,0.057459,-0.024814,-0.034711,0.057102,0.030154,0.019724,-0.044198,-0.012775,0.016053,-0.014587,-0.035392,0.057067,-0.024807,0.027059,-0.053189,-0.028387,-0.007036,0.058977,-0.000920,0.044477,0.032739,-0.048431,-0.063697,-0.045759,0.004036,0.012719,-0.055871,0.011531,-0.053173,-0.001439,-0.033389,0.036362,0.021872,-0.048160,0.015397,0.055885,-0.028278,-0.030170,0.000866,0.017798,0.018507,-0.013558,0.014129,-0.041534,0.021072,-0.046906,-0.027753,-0.008752,0.005762,0.071475,0.007968,-0.046323,-0.010919,-0.050200,-0.026526,0.015476,-0.046655,0.014857,-0.013045,-0.028161,0.020262,0.038393,-0.022729,0.047258,-0.045340,-0.004672,-0.044146,0.068182,0.042544,-0.031507,0.016051,-0.034026,-0.017621,0.053870,-0.040169,-0.052165,-0.032408,-0.007867,-0.010867,-0.026935,0.042881,-0.029224,-0.050435,0.023964,-0.025255,-0.058042,0.052237,0.047761,-0.004422,0.044607,-0.053112,-0.013688,-0.056247,-0.003810,0.038988,-0.020211,0.050227,-0.043700,-0.035334,0.054474,-0.017384,-0.032512,-0.036870,-0.050882,0.052451,-0.012579,0.058564,0.058282,0.000303,-0.065758,0.045219,0.014686,-0.035619,0.054528,0.028534,-0.027068,0.041755,0.033251,-0.031883,0.058937,-0.052716,0.044694,0.044682,-0.043574,-0.054708,-0.007494,0.059858,-0.039559,-0.032354,0.004733,0.019139,-0.051986,0.000645,-0.060954,-0.007463,-0.036688,0.016081,-0.001887,-0.043786,-0.034074,0.065897,0.006192,-0.042339,-0.014920,-0.028356,0.061987,0.058395,0.023951,-0.044940,-0.013574,-0.030741,0.027543,0.004539,0.034617,0.040386,-0.062777,-0.011210,-0.018422,0.055913,0.050205,0.036924,-0.013099,-0.052298,0.059198,0.041386,-0.025147,-0.018936,-0.023191,0.024629,-0.011157,0.038206,0.007753,-0.008798,0.034326,0.012798,0.046699,-0.007796,0.034762,0.014214,-0.040265,0.048684,0.044801,-0.011937,0.057629,0.005778,0.029315,0.009466,-0.044262,0.057148,-0.047632,-0.056385,0.018679,-0.009835,0.037830,0.003126,0.010681,-0.015208,-0.001367,0.030437,-0.066421,-0.017474,0.018375,0.027016,0.050796,0.006450,0.011730,0.016048,-0.004261,0.003614,-0.057128,0.044651,0.044972,-0.006175,0.034810,-0.007788,-0.049191,0.021742,-0.059383,-0.038762,-0.031724,-0.046391,0.054946,0.030416,-0.022904,-0.040503,-0.020668,0.005435,0.027482,-0.036477,0.013730,-0.022405};
  parameter real W2135[0:249] = {-0.029785,-0.042429,-0.027565,-0.029041,0.004545,-0.011083,-0.035900,0.055560,-0.021293,-0.032392,0.051978,-0.031846,-0.062407,-0.017177,0.054229,-0.050563,-0.021630,0.040899,-0.032486,-0.057857,-0.015167,0.012347,0.069718,-0.011531,-0.038880,-0.044940,0.009179,0.017028,0.000873,-0.026905,-0.024306,0.073074,0.044242,-0.035840,-0.002217,-0.059134,0.017044,0.032304,-0.021019,-0.021432,0.008585,0.010093,-0.046597,-0.020085,-0.061567,0.028275,0.053669,0.056955,-0.052755,0.045576,0.055841,-0.010374,-0.060867,-0.037999,0.062251,-0.018804,0.019576,0.000834,0.056593,0.029053,0.000859,-0.051122,0.039199,-0.031735,-0.039904,0.055380,0.014527,-0.020823,-0.058695,0.042772,-0.060526,0.031182,0.029162,-0.052335,0.080845,-0.059321,0.017973,-0.047342,0.029748,0.005466,0.026351,0.005429,0.059462,0.021345,0.058810,0.023431,0.030404,-0.021553,-0.002903,0.054985,0.031163,0.012148,-0.064942,0.019839,0.022700,-0.035940,0.037944,-0.017931,-0.045508,0.038978,0.048264,-0.021500,-0.051191,-0.063376,-0.041421,-0.064499,0.053975,0.005827,0.048525,-0.023040,0.016251,0.049605,0.063947,0.028386,-0.025799,0.056173,0.034790,0.009147,-0.052413,0.011213,-0.051992,-0.046263,-0.016761,0.043012,-0.033425,0.035912,0.002411,0.029880,-0.025150,0.056897,0.020946,0.043136,0.034270,-0.054815,-0.006146,0.018297,-0.061425,-0.002515,0.036690,-0.021940,-0.043911,0.034981,0.033974,-0.061180,0.027151,0.006280,-0.049530,0.041136,0.048253,0.058386,0.058897,0.065935,-0.061463,0.060871,0.004286,0.018826,0.032961,-0.024348,0.036087,0.021478,0.025304,-0.001889,0.002159,-0.056571,0.044615,-0.054798,0.056967,-0.055177,-0.001827,-0.043551,0.052339,-0.033000,-0.055583,-0.008951,0.000077,0.031776,-0.000463,-0.038380,0.017980,0.061934,0.059694,-0.006562,0.035437,0.064235,-0.017870,0.014685,0.017498,0.063488,-0.026412,0.057032,0.002882,0.003382,0.038947,-0.062037,0.005632,0.017262,-0.024363,0.052544,-0.006178,-0.032764,-0.027510,-0.001339,-0.026421,-0.000262,-0.007230,-0.054985,0.011365,0.008887,0.036298,-0.029981,-0.058555,-0.042836,0.019076,-0.000865,-0.023808,0.027260,-0.028363,-0.027698,-0.048079,0.043878,-0.018126,0.062932,-0.018978,-0.032483,0.049401,0.066710,-0.006739,-0.026366,0.011187,0.036467,0.039772,0.046140,0.012156,0.018437,0.010674,-0.015195,-0.032339,-0.055430,-0.002571,0.018009,0.063072,0.018596,-0.021697,0.057531,0.055656,0.002737,-0.014063,-0.020837,0.017568,-0.054296};
  parameter real W2136[0:249] = {0.062181,0.019375,0.005032,0.025918,0.029173,0.049091,-0.049902,-0.017836,-0.006560,0.052738,-0.054031,-0.014103,0.012855,0.055080,0.059785,-0.004249,-0.028237,-0.032661,0.051907,-0.039730,0.011415,-0.005340,-0.034804,-0.037623,0.047419,-0.061661,0.008620,0.027940,0.002008,0.023775,0.032155,0.009934,-0.011292,-0.045586,0.058524,-0.029051,0.000860,0.046019,0.006155,-0.032916,0.063441,0.013414,0.031785,-0.055536,-0.015916,0.060111,0.010090,-0.029174,-0.036129,-0.047144,-0.059391,-0.039473,0.036527,0.018258,0.041455,-0.024888,0.062609,0.056409,0.052088,-0.024110,0.016909,0.062115,-0.049689,0.038816,0.024644,0.048659,-0.036160,0.006878,-0.001692,-0.041597,0.036951,-0.002607,-0.058136,0.042178,0.002415,-0.017511,0.005692,-0.042700,-0.034098,0.014987,0.005418,-0.002983,0.024530,-0.037884,0.025458,0.013896,0.051801,0.058226,-0.037645,-0.049553,0.058226,0.032368,0.045309,-0.050848,-0.001712,0.025125,-0.023157,-0.028352,-0.014711,-0.018166,-0.017110,-0.049682,0.009952,-0.048009,-0.051225,0.014536,-0.061660,0.024827,0.045860,0.039790,0.020345,0.052245,0.060352,-0.020485,0.006589,-0.036908,-0.003667,0.026879,0.006007,0.057406,-0.051517,-0.031275,0.002776,-0.039568,0.038467,0.008730,0.000731,0.037567,-0.050621,-0.041019,-0.059482,0.032759,0.056412,0.038497,-0.004248,-0.009525,-0.000301,0.000167,-0.022204,-0.064497,0.051839,0.000206,0.009403,-0.046064,-0.035846,0.029330,-0.006437,-0.054148,0.000336,-0.005934,-0.046867,0.045220,0.029952,0.045518,0.033456,-0.038811,-0.048923,0.036446,-0.056337,-0.060940,-0.055850,0.014039,-0.039361,-0.059171,0.007664,0.036994,-0.046533,0.029933,0.049827,0.048370,-0.019496,0.009536,0.014943,0.039397,0.028981,0.061734,-0.023689,0.055351,0.016824,0.003982,-0.013397,0.000990,0.029223,-0.002642,-0.049919,-0.048110,0.050064,-0.019595,0.033472,0.005109,0.046329,-0.054831,0.051035,-0.060993,-0.023131,-0.023023,0.006815,0.019269,-0.014263,0.025437,0.004008,0.040541,-0.027447,0.017989,0.046579,-0.027992,-0.019498,0.039724,-0.019074,-0.011604,0.024192,-0.064429,0.065347,0.009074,0.054935,-0.036914,-0.030330,0.010135,-0.005786,-0.022397,0.019799,0.058502,-0.019510,-0.061727,-0.030653,-0.010251,0.036308,0.017939,-0.036410,0.044298,-0.049265,0.024096,-0.010180,-0.062306,0.016995,0.024730,0.031647,-0.052606,0.052497,0.036815,0.016078,-0.006981,-0.023044,-0.016285,0.035228,0.028608,0.029575,0.013571,0.061681,0.032628};
  parameter real W2137[0:249] = {-0.037276,0.061306,0.020772,0.035217,-0.063095,0.053496,0.008342,0.050413,0.031327,0.000463,-0.024560,-0.053854,-0.031381,0.034487,0.041923,0.011354,0.035206,0.024447,-0.034796,-0.027255,0.002246,-0.007309,0.022595,-0.019161,0.019183,-0.000755,-0.020396,0.021880,0.000422,0.054964,-0.007571,-0.000913,-0.065785,-0.065462,0.024367,0.056606,0.060048,0.060362,0.005026,0.027730,-0.030528,-0.019028,-0.040185,-0.067555,-0.027340,-0.005726,0.060476,-0.053459,-0.029986,0.047537,-0.055767,-0.008186,0.001095,0.039623,-0.040962,-0.030845,0.026204,-0.010987,-0.057284,0.007552,-0.046938,0.052124,0.030911,0.067971,0.042910,0.031190,0.004361,0.032029,-0.021776,0.017355,0.022082,0.001722,-0.063596,0.008428,0.041831,-0.008848,0.023562,-0.048903,-0.046852,-0.056216,0.010206,-0.005238,-0.030595,-0.059204,-0.068519,0.064473,0.046615,0.029092,-0.017325,-0.029832,-0.040954,0.001514,0.049109,-0.042604,0.003514,0.040730,0.027794,0.056423,0.042646,-0.005157,-0.039514,-0.027166,-0.005757,0.044604,0.032903,0.030888,-0.051250,-0.034579,-0.060744,-0.044856,-0.029814,-0.020172,0.020091,-0.008775,-0.015817,0.002318,0.030925,0.045499,-0.051757,0.000238,-0.006846,0.012495,-0.042539,0.043942,0.020741,0.031868,-0.022540,-0.045273,0.024390,-0.056192,0.000743,0.047370,-0.012233,-0.036324,0.040469,0.028202,-0.022044,-0.014718,-0.037581,0.057111,0.005231,-0.031880,0.022976,-0.049892,-0.009048,0.003607,-0.045852,0.008538,0.057429,0.018658,0.051714,-0.006084,0.058871,-0.014623,0.029955,-0.062956,-0.030241,0.025904,-0.046954,0.011118,-0.050935,0.046058,-0.023466,-0.014579,0.001516,-0.012528,0.003073,-0.065549,0.069497,0.019743,0.054594,0.013139,-0.043436,-0.048373,-0.025624,-0.019554,-0.049362,-0.032139,-0.048137,-0.062768,-0.046050,-0.038850,-0.057852,-0.022642,-0.058194,0.061235,-0.067672,-0.013710,0.058906,-0.046314,0.031984,0.048928,0.021005,0.026827,0.018270,0.053107,0.045857,0.064505,0.025728,-0.010269,0.029901,0.014387,0.025770,0.023320,0.037517,0.019564,-0.021673,0.002797,-0.024705,0.011193,0.070350,-0.023912,0.004949,-0.039649,-0.013712,0.014256,-0.003367,-0.008104,0.030558,-0.044429,0.017155,-0.022543,0.065768,-0.026959,-0.000720,-0.065431,-0.046918,0.052066,-0.049146,0.006970,0.039458,0.055881,-0.007123,-0.003884,-0.016330,-0.045495,-0.049432,-0.034891,0.001685,-0.031270,-0.010664,0.007940,0.047164,0.012212,-0.038401,-0.031200,-0.003444,-0.053161,0.065342,-0.053180};
  parameter real W2138[0:249] = {-0.025687,0.046322,0.050032,-0.007759,0.063886,-0.032721,0.002580,0.018264,0.007685,0.013414,-0.014673,-0.030609,-0.061381,0.051242,0.052585,0.018778,-0.001594,-0.005452,-0.034443,-0.062140,0.057407,-0.060943,-0.024264,-0.012050,-0.018141,0.045534,0.042037,-0.000634,-0.051082,-0.008340,-0.003834,0.000412,-0.029394,0.038649,0.068673,0.038271,-0.031394,0.038236,-0.007856,-0.010844,0.047537,0.013253,-0.067458,0.063510,0.055162,0.000041,0.009764,0.014643,-0.035008,-0.056140,0.002526,0.009122,0.014002,0.020891,0.057336,-0.030953,-0.062848,-0.010520,-0.008235,-0.022578,0.020407,0.008594,0.009804,-0.039759,-0.073992,0.020472,0.052333,-0.022813,-0.013663,-0.025440,-0.005742,-0.027576,0.061701,0.045433,-0.021330,-0.002036,-0.035835,0.050629,0.047430,-0.048196,0.009822,0.064058,-0.054030,-0.038008,0.061046,0.036159,-0.013697,0.019608,0.037095,-0.044028,-0.040638,-0.057609,0.032234,-0.044139,0.017052,0.029286,-0.012798,0.028999,-0.012605,-0.014270,0.019135,-0.037644,-0.017382,0.018773,-0.026394,0.003798,-0.055599,-0.024798,-0.035323,0.039177,-0.050812,0.051865,-0.048570,0.011682,-0.059650,-0.029830,-0.048425,0.031866,-0.028210,-0.053736,0.031162,0.037485,0.001281,0.020630,0.020481,0.009354,0.034530,0.061873,0.046956,-0.035816,-0.034736,0.071036,-0.002607,-0.002052,-0.010626,-0.002578,0.033821,-0.049988,0.033689,0.024031,-0.057681,-0.039103,-0.059893,-0.007619,0.015433,-0.009319,-0.056784,0.052860,-0.001049,0.059444,0.057754,-0.031783,0.064144,-0.003739,-0.050282,0.039292,-0.000993,0.052434,0.029002,-0.012675,-0.027425,0.000922,0.004757,0.039350,0.023473,-0.025522,-0.028980,-0.043978,-0.012817,-0.012173,0.022919,0.051424,-0.041452,-0.010388,0.049566,-0.037671,-0.047936,-0.026157,0.017138,-0.005437,-0.032073,0.042302,-0.028529,-0.023976,0.022554,-0.018904,-0.019584,-0.030652,0.018405,-0.015031,0.020616,-0.034883,0.022352,-0.017916,0.020177,-0.061619,0.042762,0.051371,0.018477,0.059758,-0.061072,-0.032373,-0.035483,-0.057860,0.007751,0.038249,0.029705,-0.019561,0.026793,-0.018384,-0.058640,0.007759,0.008630,-0.050080,0.013718,-0.028847,0.008897,-0.001896,-0.019368,0.040149,0.026264,-0.016749,-0.020275,-0.032520,0.012255,0.026970,0.008466,0.053261,-0.003411,-0.012360,0.057976,0.067530,0.048272,0.018473,-0.067206,0.050647,-0.050253,0.047826,0.017176,-0.010662,-0.005032,-0.030723,0.051893,-0.035175,-0.018833,0.053001,0.068164,0.015245,-0.070988,-0.036359};
  parameter real W2139[0:249] = {-0.033624,0.000045,0.053283,0.018089,-0.020811,0.009936,-0.000371,-0.038553,0.045525,0.025109,0.051114,0.030535,0.032364,0.004651,0.037092,0.005671,-0.007821,0.052228,0.010244,0.007766,0.054267,0.033360,0.046163,0.040250,-0.048228,-0.019148,0.047514,-0.011770,-0.048908,0.041978,0.029110,-0.043373,-0.032825,0.024696,-0.041934,-0.002088,0.039160,0.008375,0.002635,0.042956,0.018648,0.052564,-0.004638,-0.029431,-0.018472,0.020718,0.000804,0.041770,-0.008939,0.054191,-0.004192,0.014831,-0.009740,0.000331,0.061979,-0.026882,0.006972,0.038860,0.020774,0.014703,0.042488,-0.055826,0.055242,-0.044532,-0.029750,-0.063006,0.008145,-0.021583,-0.015576,-0.025940,0.042379,-0.058638,-0.013906,-0.045805,-0.059468,0.051213,-0.005592,-0.016309,-0.011855,-0.056821,-0.018158,0.010951,-0.060724,0.007864,0.058689,-0.044578,-0.022505,0.046341,-0.042293,0.025114,0.057783,-0.050176,0.052495,-0.025562,0.024181,0.035711,0.010813,-0.028075,0.050505,-0.012663,-0.012988,0.056381,-0.060673,-0.018702,0.004231,0.045451,-0.036920,0.008153,-0.028097,-0.041400,0.045963,0.044354,0.054795,-0.003156,0.010415,0.001699,-0.013744,0.017105,-0.005715,-0.040152,0.023131,0.053818,0.049508,-0.009447,-0.002818,0.007205,-0.051884,-0.047470,-0.058141,-0.024099,0.059599,0.059196,0.029992,-0.053904,-0.035602,0.040875,0.005743,-0.052219,0.043534,0.001979,0.018739,0.055562,-0.037923,0.033561,-0.050309,0.009428,0.022324,0.047108,0.027054,-0.039677,-0.031917,-0.028114,-0.042663,-0.001166,0.052802,0.001329,-0.009274,0.032974,0.021540,0.000430,-0.045852,0.014951,0.045107,-0.028612,-0.064965,0.010373,-0.029634,-0.059660,-0.047984,0.044932,0.050307,-0.054867,-0.007518,-0.000510,-0.005614,-0.011599,-0.050244,0.022923,0.041909,0.062554,0.003484,-0.038275,-0.038583,0.060567,-0.042431,0.019292,-0.032889,-0.003043,-0.013946,0.037603,0.040750,-0.007944,-0.031364,0.014384,-0.036995,0.025809,-0.026272,-0.038772,-0.012638,0.017746,0.056944,-0.055580,0.002107,-0.014300,-0.018354,-0.008436,-0.049124,-0.032754,0.049162,-0.001998,-0.043663,-0.056580,0.007157,-0.011316,0.062698,0.029278,0.019106,0.039794,-0.020441,0.049266,0.043990,0.060370,0.051016,-0.028985,0.009841,0.031036,0.007599,-0.036100,0.011561,0.038921,0.029048,-0.029736,-0.066828,0.059838,-0.021321,-0.035392,0.004447,-0.059623,0.048007,0.004991,-0.001110,-0.042246,-0.003236,0.057089,-0.003843,-0.046378,-0.034838,-0.034307,0.013545,0.051793};
  parameter real W2140[0:249] = {-0.024326,-0.029120,0.020473,-0.008333,-0.033414,-0.048903,-0.051210,0.017656,-0.057527,0.024690,0.054838,-0.043622,-0.047778,-0.022625,0.013049,0.033666,0.050976,0.063402,-0.033392,-0.032646,0.015306,0.015398,0.041398,0.053949,-0.000636,-0.059188,-0.008401,-0.007821,-0.039666,0.009532,-0.023322,-0.023380,-0.039372,0.027347,0.069177,-0.035178,-0.023267,0.049141,-0.022183,-0.032644,0.035474,0.007860,0.002879,0.025996,0.054123,-0.048317,-0.005220,-0.013581,-0.031136,0.047462,-0.057831,-0.062431,-0.011455,0.024695,-0.004751,-0.003107,0.005377,0.056005,-0.010570,0.032576,0.030438,-0.040900,-0.050450,-0.034914,-0.060215,-0.024416,-0.016571,0.055774,-0.012310,0.061052,-0.016541,-0.031446,0.033904,0.001891,0.053575,-0.031370,-0.055142,-0.017510,0.012077,0.027431,-0.019413,-0.028588,-0.040328,0.034581,-0.060640,-0.032980,0.029260,-0.001958,0.030086,0.035615,-0.011867,-0.032688,-0.016418,-0.060274,-0.043314,0.043190,-0.017354,0.027589,0.035878,0.060151,0.052612,-0.056502,-0.057535,0.030071,0.044733,0.060059,-0.061802,0.025462,-0.024161,-0.032205,-0.054752,-0.040959,0.016823,0.006419,-0.016977,-0.007195,-0.003122,-0.060543,-0.039014,-0.000896,0.004040,-0.008903,0.044862,0.025062,-0.010136,-0.062741,-0.042846,-0.000856,0.063627,-0.024338,0.033839,-0.042456,0.027673,-0.024418,0.045996,-0.050575,0.048665,0.004779,-0.040770,0.046728,-0.013389,0.043714,-0.020289,0.001299,0.019355,-0.019044,-0.045154,-0.026460,0.030753,0.048067,0.061714,-0.018859,-0.033118,-0.052179,0.008312,0.055234,0.011549,-0.033638,0.048815,0.032095,-0.049326,0.023764,-0.037543,-0.038503,-0.025947,0.045818,-0.043985,-0.019162,0.026487,0.019617,0.052718,-0.024158,0.034766,-0.027568,0.047531,-0.043542,0.051420,-0.025358,-0.002823,0.004847,-0.011271,0.045481,-0.019950,-0.009733,0.040926,0.016736,-0.019088,-0.049464,0.033572,0.002596,-0.051556,-0.023345,0.021042,0.022244,0.043195,0.022134,-0.019531,0.048916,-0.018607,-0.019281,0.051994,-0.013303,-0.033138,-0.058000,0.041779,0.061667,-0.002373,-0.029747,-0.059568,-0.056468,0.049220,-0.043381,-0.045274,-0.045647,0.048188,0.057600,0.057898,-0.012430,-0.034422,-0.045339,0.043196,-0.028246,-0.019320,0.009827,0.028680,0.052134,-0.028286,0.012154,0.039472,0.056821,0.055627,-0.023361,-0.052167,-0.056326,-0.014717,-0.025625,-0.011988,0.056527,-0.040370,0.011986,-0.024840,-0.033431,-0.000536,0.055182,0.028268,0.032173,0.010908,0.066232,-0.032764,0.005134};
  parameter real W2141[0:249] = {0.047216,-0.008578,-0.003296,-0.000406,0.048020,-0.062156,0.047108,0.060491,-0.016417,0.023850,0.035490,0.014297,-0.057794,-0.060019,-0.004427,0.000301,-0.038387,0.040184,-0.050128,0.010978,0.011585,-0.003217,0.055254,0.033771,0.016722,0.013066,-0.012707,0.020856,-0.036695,0.010141,0.049080,-0.060201,-0.056006,0.040839,0.041349,-0.006236,0.040535,-0.029989,-0.064424,-0.034545,-0.058314,0.036251,-0.047656,0.021468,0.024541,0.013268,-0.053807,0.049945,0.052627,0.056946,-0.041050,-0.011850,-0.052147,-0.048622,-0.036886,0.031583,-0.048748,-0.015383,0.049338,0.017608,-0.046316,-0.048758,0.057427,-0.059595,0.014449,-0.025240,-0.028271,0.056697,0.022949,-0.002755,0.048028,-0.047518,-0.039442,0.051570,-0.047888,-0.023353,-0.063966,0.063129,-0.044801,-0.020622,0.053930,-0.057595,-0.013524,0.001295,0.058366,-0.015988,0.009128,0.046014,-0.059608,0.005119,0.015005,0.031083,0.031512,0.034020,-0.052924,-0.061832,0.010649,0.034390,-0.012674,0.038326,-0.015287,0.046646,0.006337,-0.053952,0.063623,0.013652,0.041078,0.019543,0.010276,0.040535,0.034786,-0.006259,-0.026646,-0.039169,0.010033,0.048746,0.034816,-0.020762,0.030898,-0.008136,-0.062823,0.001506,-0.032754,0.037184,0.022421,-0.043207,0.014150,0.048157,0.043783,0.004930,-0.042006,-0.019468,0.037843,-0.026946,-0.038103,0.055777,-0.014385,0.015925,-0.062732,0.012278,0.025090,0.023657,0.024625,-0.014359,0.026039,-0.033651,-0.045587,-0.013019,-0.045433,-0.016547,-0.045088,0.056310,0.036167,-0.055013,0.038271,-0.011401,0.052386,0.061716,0.032682,-0.015083,-0.045395,-0.060411,0.022101,-0.053629,-0.048327,0.026840,0.019074,-0.051231,-0.028858,-0.021708,-0.042352,-0.041711,-0.025613,0.030737,-0.018756,0.056662,-0.046112,-0.040707,-0.041727,-0.043126,0.014188,0.015867,0.039457,-0.040978,-0.063145,-0.047564,-0.050695,0.062918,0.062745,-0.023009,-0.031495,0.045446,0.048412,0.022904,-0.014904,0.032816,0.030769,-0.025654,-0.056000,-0.003032,0.038143,0.002861,0.003766,0.062811,-0.002032,0.035911,-0.056471,0.028199,-0.035270,0.031770,0.052589,0.012211,0.025216,-0.014712,0.031982,-0.021564,0.023015,0.053809,0.051303,0.018761,0.037822,-0.020814,0.058254,0.055747,-0.002524,-0.029840,0.012452,-0.031235,-0.034915,0.046064,-0.009378,-0.040860,-0.048063,-0.050304,-0.012965,0.002390,0.020477,0.010835,0.031596,0.026115,0.034121,-0.005713,-0.034073,-0.025920,0.001400,0.015702,0.013376,-0.023922,0.015253,-0.021542};
  parameter real W2142[0:249] = {-0.025586,-0.023751,0.033449,-0.051488,-0.008007,-0.043444,0.036247,0.039213,-0.038469,-0.019982,-0.009374,0.008258,-0.052303,-0.004013,0.042193,-0.043958,0.043426,-0.022560,-0.005016,-0.000879,-0.009646,0.039699,-0.001776,0.019405,-0.062895,-0.040363,-0.026610,0.023654,-0.036512,0.013992,0.055191,-0.027867,-0.046504,0.053902,0.021807,0.018181,0.003799,-0.007349,-0.042367,0.021101,0.037955,-0.017148,0.014370,0.054658,-0.007746,0.022687,-0.012079,-0.002503,-0.006476,-0.049454,-0.033486,-0.015685,-0.041159,-0.011666,-0.035892,0.066563,0.042534,-0.061236,0.019155,0.039416,-0.055136,0.054508,0.043102,0.009571,0.028918,-0.007172,0.052992,0.000165,0.059498,-0.026705,-0.042939,0.035839,-0.042914,-0.033429,-0.052264,-0.011920,0.004981,-0.006153,0.059680,0.027905,-0.056592,-0.021764,0.043493,-0.062216,-0.004172,-0.004474,-0.038120,0.013581,0.007700,-0.045974,-0.044181,0.022639,0.061881,0.026338,0.037055,-0.005950,-0.029283,0.043083,-0.028198,0.000792,-0.028907,0.035686,0.007458,0.021910,0.046863,-0.005975,-0.064140,0.029608,-0.030544,-0.036451,-0.047984,-0.024401,0.045029,0.005879,-0.021936,0.042062,-0.039233,-0.063195,-0.036179,-0.060786,-0.018801,0.041977,0.022751,0.062015,0.017093,0.023115,-0.001022,0.049778,0.011475,-0.012348,0.025783,0.022866,-0.034019,0.033813,0.043503,0.030832,-0.044180,-0.008162,-0.032313,0.041397,0.009935,0.059871,0.012625,0.046774,0.058133,0.006102,0.055717,0.021422,0.059718,-0.019165,0.013387,0.014088,0.051378,0.007564,0.009691,0.046525,-0.059504,0.048397,-0.000618,-0.009096,0.035302,-0.047998,-0.057737,-0.025483,0.055356,0.012109,-0.057460,-0.052708,-0.017646,0.056436,0.065697,0.019971,-0.067697,-0.054148,-0.039145,-0.012829,0.027506,0.054976,0.049112,0.032046,-0.062528,-0.036786,-0.001356,-0.034537,0.013660,-0.038098,0.059495,0.060277,0.045782,0.023924,0.019463,-0.023109,-0.055901,0.059998,-0.047932,0.018959,0.045628,0.045768,-0.050064,0.023992,-0.027770,0.006055,-0.055551,0.003783,0.039852,-0.063735,0.023715,-0.050709,0.012632,-0.011159,-0.062758,0.033495,-0.011933,-0.002422,0.036105,-0.048120,0.043735,-0.014921,0.045642,0.057419,0.023170,0.016293,-0.042503,-0.032970,0.035290,-0.061115,-0.011635,-0.018306,-0.015440,-0.026530,-0.041669,-0.017956,-0.012918,0.051071,-0.026458,0.000624,-0.064970,-0.021044,-0.027172,0.029038,0.010032,-0.050583,-0.045933,0.033361,0.013800,0.012654,-0.032055,0.004441,-0.046750,-0.031051};
  parameter real W2143[0:249] = {0.044655,-0.001440,-0.001032,-0.002277,-0.001263,0.030700,-0.059631,-0.036822,0.007736,-0.047269,0.039044,-0.029516,0.009478,-0.038161,-0.001819,-0.060756,-0.009002,-0.055315,-0.008888,-0.059425,0.018708,0.053454,-0.039358,-0.035736,0.051650,0.010043,-0.005168,0.027509,0.042018,-0.060335,-0.044050,0.062714,0.019844,0.037093,-0.059162,-0.054268,0.061598,0.013771,-0.004075,0.036656,0.062319,0.014042,0.013326,-0.006391,-0.023853,0.003648,-0.023717,-0.019344,0.050914,0.006537,0.029358,0.012845,0.032582,-0.007654,0.031535,0.035804,0.029876,-0.053835,-0.020978,-0.072656,0.058534,-0.033644,0.018837,-0.025939,-0.029227,0.007062,-0.037763,-0.007095,-0.039568,-0.060167,-0.008081,0.040402,-0.042449,-0.055940,0.073380,0.039665,-0.026755,-0.001701,-0.000717,-0.038847,-0.017577,-0.008605,-0.050008,-0.019493,0.027288,0.021274,-0.006756,-0.049938,0.044825,-0.019608,0.057519,0.013313,-0.057360,0.008756,-0.046361,-0.068909,-0.034185,-0.028987,-0.029095,-0.006347,-0.033425,0.069823,0.025102,-0.070367,0.026911,-0.010340,0.072622,-0.047943,-0.003761,-0.009423,-0.059171,-0.043631,-0.035057,-0.036569,0.046155,-0.056583,-0.024357,0.064455,0.030319,0.065496,-0.088534,-0.031152,-0.003322,-0.063968,0.035644,-0.004979,0.053795,0.026046,-0.042979,0.005641,-0.055946,0.016386,-0.058219,0.024393,-0.049242,-0.011151,-0.026300,-0.044810,-0.060470,-0.031075,-0.033526,0.043577,-0.030810,-0.013668,0.023335,0.065073,0.015923,0.051508,-0.017802,0.039563,-0.018450,0.055393,-0.020931,0.061053,0.034983,-0.029560,0.002132,0.028904,-0.044712,-0.050440,-0.000947,-0.027162,-0.045903,-0.022214,-0.049512,0.034042,-0.038816,0.044362,0.014134,-0.033491,-0.060164,-0.021132,-0.019063,0.045612,-0.023347,-0.041486,0.046869,0.000221,0.022443,-0.012277,0.008832,-0.008845,-0.046083,0.048958,-0.048723,0.043091,-0.009977,0.021395,0.014026,-0.045021,0.057962,0.066644,-0.025955,-0.028371,-0.031169,0.023055,0.014831,0.014312,0.003727,0.014193,0.008410,0.036338,0.021055,-0.063937,-0.058453,-0.056983,0.028472,0.041909,-0.041609,-0.024545,-0.044120,-0.003994,0.056241,-0.069486,-0.067027,-0.020691,0.054807,0.015216,-0.009707,0.015230,-0.046013,0.030076,0.060331,-0.040784,0.036744,0.018665,-0.022202,-0.052533,0.053565,-0.024319,0.010429,-0.032281,-0.005827,-0.035259,0.003448,0.026574,0.026025,0.002974,0.053501,0.001480,-0.013549,0.018223,0.038025,0.003557,0.061077,-0.024656,0.042049,0.004679,-0.053561,0.016487};
  parameter real W2144[0:249] = {0.043637,0.052528,-0.037786,0.007015,-0.058056,-0.007516,-0.049901,-0.025500,-0.041054,-0.042838,0.044763,-0.010684,0.056831,-0.008384,-0.012786,-0.023029,0.041220,-0.026033,-0.014383,-0.020317,0.054514,-0.055599,0.039846,-0.000124,-0.001904,0.048299,-0.019422,0.018556,-0.039733,-0.037090,0.037956,-0.044885,0.063067,0.016440,-0.037144,0.057964,-0.018178,-0.033501,0.037811,-0.060041,0.020446,-0.058207,0.024754,0.043691,0.007446,-0.023783,0.035264,-0.021574,0.059822,-0.033027,0.001748,-0.017844,0.039028,0.060925,-0.002891,-0.031162,-0.034808,0.042544,0.024650,-0.023353,0.024057,-0.046329,-0.041190,0.016774,-0.023697,-0.035525,-0.008643,-0.029533,-0.074984,0.012127,-0.015047,0.059569,0.026317,0.059433,-0.033612,0.057156,0.006185,-0.052182,0.032469,0.036814,-0.062230,-0.017027,-0.000669,0.035151,0.059091,0.025427,-0.055932,0.047967,0.039061,-0.048367,0.033068,0.032275,0.046797,0.015547,-0.038452,-0.011280,-0.021444,0.048248,0.045153,-0.037701,0.021084,0.031941,0.046454,-0.056589,0.012559,0.000184,-0.005260,-0.046923,0.032312,0.020463,0.009271,0.007636,0.030272,0.040033,-0.013977,-0.015418,-0.077883,-0.032772,0.016611,-0.035016,0.029188,-0.027184,-0.029191,-0.043688,0.020262,0.056948,-0.004066,-0.029281,0.060811,0.010387,-0.021834,-0.064391,0.032940,-0.010216,-0.025403,-0.016140,-0.020922,-0.027337,0.028670,0.019486,-0.005512,0.055448,0.041599,0.047135,0.064905,0.028107,0.056297,0.047590,-0.014513,0.018044,0.003144,-0.018889,-0.018218,-0.038802,-0.066420,0.020458,0.020710,0.000958,-0.036625,0.054714,-0.054601,0.057275,0.015694,0.026408,0.006607,0.006343,0.033434,0.052190,0.057347,0.004507,-0.020650,-0.022147,0.034091,-0.038769,0.039337,0.005117,0.009381,-0.056509,0.066957,0.023585,0.062038,-0.046929,0.021194,0.060184,-0.025398,0.054026,0.035909,-0.063376,0.062245,-0.018281,0.018465,0.016084,0.022008,0.025886,-0.005788,0.023608,-0.034250,0.001975,-0.025424,0.044877,0.051856,-0.019086,0.038439,0.060888,0.028458,-0.018040,-0.019131,-0.016637,-0.050507,0.042983,-0.003101,0.025868,-0.030129,0.024696,0.065059,0.007345,0.003330,-0.012876,0.049612,-0.033327,-0.043314,-0.057896,-0.000637,0.010503,0.038469,-0.042369,-0.010058,0.031997,0.059769,-0.050889,-0.051853,0.029494,-0.052681,0.043197,0.004393,0.013783,-0.002914,0.037329,-0.051813,0.042409,-0.043578,-0.030554,-0.012664,0.025706,-0.046248,-0.004384,0.032415,0.004933,-0.041842,0.040723};
  parameter real W2145[0:249] = {-0.030621,-0.035250,0.057246,-0.043470,-0.007775,0.059529,-0.054274,0.029985,-0.006391,-0.047058,0.006181,0.048985,-0.038851,0.053192,0.042405,0.025619,-0.046024,-0.022776,0.038516,0.016314,-0.042092,-0.041509,0.005555,0.029400,0.042771,-0.053991,0.046936,-0.041648,0.040886,-0.007138,0.054716,-0.010990,0.034768,0.035186,0.047651,-0.058251,0.001040,0.003512,0.065126,0.017881,0.034763,-0.053611,0.063657,0.012176,0.039970,-0.036030,0.043208,-0.032153,-0.039725,-0.042762,-0.043606,-0.011920,-0.027252,0.018352,-0.048271,-0.008590,-0.012854,0.012814,0.038381,0.021917,-0.021538,0.028265,0.031879,0.039952,-0.014055,0.034303,-0.060208,-0.052328,0.008248,0.001446,-0.039599,0.028749,0.026242,-0.036189,-0.022469,-0.004164,0.009675,0.033915,-0.039165,0.051794,-0.016065,-0.003742,-0.014043,0.009191,0.056196,0.027366,-0.060783,0.038798,-0.054985,0.033671,-0.052038,0.005741,-0.057956,0.045638,0.044670,0.063935,-0.067987,-0.060783,-0.004687,-0.027620,0.052654,-0.034126,0.040282,0.054066,0.065283,-0.054596,-0.053675,0.037377,-0.022387,0.035972,-0.061323,0.024805,0.004835,0.040342,-0.032766,0.034845,0.041621,-0.066650,-0.054991,-0.045415,-0.003930,0.026667,-0.032126,0.019034,0.034681,0.051966,0.010706,-0.034369,-0.048845,0.057265,0.005041,0.061411,0.045734,0.040519,0.000272,-0.051368,0.016293,0.042556,-0.047732,-0.005323,0.011522,-0.006982,-0.031586,0.021829,0.041937,-0.025377,-0.010966,-0.048212,0.053383,0.030943,0.001131,0.041090,-0.008530,-0.036246,0.013400,0.039200,0.053890,0.034754,0.040630,-0.011592,0.028142,-0.053351,-0.002004,-0.025396,-0.024671,-0.017929,-0.035635,0.049102,-0.027451,0.025565,-0.039719,-0.048649,-0.031978,-0.051455,0.005616,-0.005174,-0.010116,-0.033643,0.044242,0.062643,0.010062,-0.005090,-0.004406,-0.017893,0.037114,-0.011648,0.021654,-0.009290,0.008045,-0.000177,-0.010403,0.013994,-0.007900,-0.033914,-0.047605,-0.017128,-0.035135,-0.052952,-0.032897,0.008300,-0.015349,0.007524,-0.035999,-0.060256,0.021898,0.014264,0.051267,0.051124,0.022392,-0.034333,-0.031432,-0.013497,-0.054982,-0.029126,-0.017178,-0.023377,0.046372,-0.001384,0.014719,0.034096,0.006195,0.037758,-0.007590,0.051768,-0.055272,-0.034504,-0.029025,0.024632,-0.004580,0.017388,-0.016348,0.039837,-0.004130,-0.028632,-0.008755,-0.015309,0.028502,-0.033255,0.018795,0.018747,-0.033307,0.006974,0.004217,-0.047596,0.018962,-0.042313,0.001574,0.013438,-0.029165,-0.043985};
  parameter real W2146[0:249] = {-0.018985,-0.030697,-0.026131,-0.003922,-0.023138,-0.059113,0.001202,0.007174,0.037066,0.068194,-0.047946,0.023288,-0.007437,0.038928,-0.004807,0.013761,-0.058287,0.054101,0.024619,0.005949,0.018026,-0.043147,-0.047623,0.046354,0.036499,-0.020658,0.002065,0.045661,0.009812,0.000861,-0.053249,0.032570,-0.016376,-0.038847,-0.065564,-0.008665,0.059000,-0.005556,0.049199,0.029553,0.048322,-0.031259,-0.023330,-0.015818,-0.013537,0.037027,0.053338,0.009510,0.048677,0.045164,-0.057263,-0.034033,-0.053542,0.000011,0.011519,-0.056051,0.041575,0.006776,0.001237,-0.033001,0.047408,0.019378,-0.011413,0.034655,-0.033910,-0.000464,-0.009886,0.055186,-0.036541,0.019049,0.053357,-0.048818,0.051778,0.061819,-0.028498,-0.045744,-0.059339,-0.027562,-0.050080,-0.050960,0.006961,0.002302,0.043889,-0.007736,0.061202,-0.035814,-0.049107,-0.022721,-0.025977,-0.049767,0.046543,0.055164,0.063032,-0.022751,0.017075,-0.026261,-0.047464,0.015171,-0.045620,0.034409,-0.059696,-0.029369,-0.025016,-0.049750,-0.008544,0.030165,0.066652,0.050114,-0.027838,0.030655,-0.022270,-0.059412,0.029437,-0.016119,-0.046505,-0.046994,0.011294,0.059127,-0.050728,0.041736,0.004647,0.000309,0.038998,-0.017320,0.060822,0.036099,-0.025215,0.008093,0.037538,-0.064032,-0.015437,-0.017047,0.040482,-0.052125,-0.025951,-0.009493,-0.039210,0.021104,0.007466,-0.006346,0.015507,0.047092,0.039748,0.058638,-0.035569,0.035225,0.035040,0.039420,-0.064943,-0.057505,0.010521,0.043830,-0.009983,0.033416,-0.045525,0.057239,-0.034361,-0.056358,-0.067841,0.048574,0.047959,0.014745,-0.030273,0.023008,0.043441,0.018008,-0.009238,0.045331,0.000270,0.011074,-0.041009,0.064339,0.034675,0.055135,-0.028969,0.037249,-0.056581,-0.039450,-0.011961,0.005375,0.020325,-0.002769,0.048511,-0.036071,0.051114,-0.041770,-0.037225,0.065059,-0.036033,-0.049998,0.013920,0.021961,-0.007224,-0.016694,-0.032437,-0.015350,0.046731,-0.004298,-0.052316,-0.067565,0.017637,-0.039666,-0.029712,0.037226,0.045748,0.045074,-0.055912,0.036389,0.024372,-0.053336,0.011083,0.031550,0.040933,0.039731,-0.048597,0.030792,-0.019922,-0.020108,-0.052143,-0.054870,0.012088,-0.024429,-0.057746,0.054777,0.046740,0.041290,-0.058018,0.017386,-0.019161,-0.039627,-0.022875,-0.003703,0.001499,0.015044,0.001583,-0.027753,0.016383,-0.004016,0.030696,0.065228,0.016765,-0.045219,0.052991,0.021530,-0.053536,-0.042488,0.033433,-0.038197,-0.005539,-0.035846};
  parameter real W2147[0:249] = {0.017076,0.000513,-0.047927,0.043378,0.041907,-0.051980,-0.062743,0.061214,-0.056947,-0.019093,-0.036465,0.004222,0.000896,-0.052445,0.046614,0.042784,0.036912,0.035941,0.060051,-0.055719,-0.001857,-0.056364,0.045835,-0.041569,-0.003105,0.026329,-0.060558,0.001756,-0.041361,0.063465,-0.000063,0.054092,-0.035779,0.038921,-0.008416,0.055383,0.018830,-0.047560,0.043171,0.029146,-0.032441,0.028735,-0.041401,0.039035,-0.016664,-0.000569,0.054292,0.048237,-0.032823,-0.004418,0.047133,-0.017489,-0.030335,-0.019060,0.017876,-0.001491,-0.023763,0.012290,0.041749,-0.007743,0.024938,0.045076,-0.039945,-0.029818,0.034962,-0.042826,0.026807,0.025171,0.003070,-0.013953,-0.013269,0.017131,-0.007876,0.002947,-0.060013,-0.018795,0.044863,0.019428,-0.062066,-0.023657,-0.044933,0.006321,0.034404,-0.005635,0.035941,-0.005840,0.059411,0.016764,0.033395,-0.061758,0.003420,-0.053242,-0.043007,0.055747,0.048119,0.065674,0.039027,-0.034987,0.024595,-0.044842,-0.011054,-0.028268,-0.015924,0.049363,0.058733,-0.013678,-0.025380,-0.058784,0.034047,-0.039022,0.051385,-0.006350,-0.012143,-0.054744,-0.031421,-0.015427,-0.047284,-0.035616,-0.018490,-0.066180,-0.002378,0.023337,0.009009,0.041656,-0.050339,-0.044821,0.021208,0.043975,-0.049644,0.043350,0.004889,0.006810,0.009878,-0.048105,-0.055961,0.054562,-0.045114,0.012909,-0.034907,-0.056601,0.053524,-0.042025,-0.042159,0.004120,-0.053845,0.028151,0.030992,0.060297,-0.047619,0.023493,-0.020651,-0.037071,-0.016514,0.050938,0.008603,-0.051682,-0.056211,-0.007451,0.039836,0.020658,0.012856,-0.033810,0.056976,-0.017635,-0.041839,0.059135,0.012291,-0.045571,0.013752,-0.026785,0.008897,-0.003474,-0.019022,-0.025446,-0.057604,-0.052846,-0.004584,0.020789,-0.046833,-0.004287,0.039491,-0.040934,-0.034911,0.047252,-0.012400,-0.045616,-0.011665,0.051954,-0.016301,0.059557,-0.039808,0.045396,0.047157,-0.017829,0.065413,0.026805,0.020997,-0.043229,0.034404,0.043317,0.063347,0.020103,-0.006826,-0.049203,-0.019235,0.047695,-0.058131,-0.005023,-0.045892,0.027333,-0.040207,-0.051483,0.033373,0.016638,-0.012530,-0.003303,0.047751,-0.046388,-0.057066,0.043406,0.017411,0.007896,-0.018901,-0.052505,0.002349,0.004323,-0.014129,-0.030294,0.028852,-0.003687,-0.023269,-0.031828,-0.027346,0.008225,-0.035442,0.004207,0.033693,0.062207,0.002046,0.023028,-0.040645,-0.058813,0.006392,-0.046210,-0.018422,0.052738,0.052601,-0.042338,0.023856,0.007378};
  parameter real W2148[0:249] = {-0.038286,0.034808,0.016245,-0.031085,0.044244,-0.049829,0.001113,0.008784,-0.034709,0.002185,0.011317,0.020381,0.023194,0.016719,-0.054436,0.028535,0.058690,0.057492,0.031860,-0.047763,0.027273,0.020123,-0.007868,-0.042500,0.021621,0.035759,0.050725,0.049542,-0.024984,0.045752,-0.029080,0.061656,0.017073,-0.032393,-0.067594,-0.052013,-0.059172,0.032775,-0.017692,0.063097,-0.044697,0.050628,-0.051210,-0.028745,0.014210,0.020030,-0.000824,-0.057691,-0.040292,-0.059820,0.000876,0.006560,0.032164,-0.042456,0.003243,0.042298,0.045543,-0.022633,-0.007926,-0.055230,0.015558,0.041565,0.054124,0.046494,-0.056378,0.032711,0.001272,-0.003534,0.012866,0.053684,0.012069,-0.002566,-0.046710,0.045008,0.018456,0.022745,-0.007096,-0.047362,-0.000034,0.045896,-0.061781,-0.002394,-0.048747,-0.042984,0.015263,0.003942,-0.026119,0.028084,0.060071,-0.045945,-0.057432,0.012499,0.050894,-0.044734,-0.053598,-0.044911,-0.035396,-0.024942,0.055969,0.004165,-0.006208,0.024126,0.006323,0.026427,0.019218,0.040711,0.035335,0.000972,0.000031,-0.007063,0.041109,0.059136,0.044681,0.015758,-0.013969,0.030491,0.055716,0.005289,0.047436,-0.028594,0.012465,-0.031223,-0.008490,0.015628,-0.016141,-0.001144,-0.041626,0.049832,-0.031130,0.052225,0.018651,0.043950,0.035208,0.011107,0.049416,0.011587,0.000251,0.029305,0.038116,-0.007345,-0.028214,0.051274,-0.034032,0.033604,0.017051,0.010373,-0.003054,0.015482,0.029348,0.029765,-0.058565,0.063135,0.052709,0.018678,-0.002608,0.059841,-0.060153,-0.041321,-0.022783,-0.038215,0.062631,-0.018570,-0.013122,0.038284,0.034739,0.032119,0.024135,0.023038,0.038015,0.051839,-0.027438,0.015619,0.026884,-0.024206,0.033271,0.062665,-0.002241,-0.056921,-0.022528,0.023256,0.036302,0.020422,0.020319,-0.028918,0.033500,0.061140,-0.047980,-0.018478,-0.006752,0.054067,0.035037,-0.041876,0.039606,0.028870,-0.019897,-0.017741,-0.044686,0.013334,0.030097,-0.015935,0.015458,-0.032787,0.016866,0.062998,-0.023518,0.022172,-0.001844,0.047658,-0.035590,-0.019429,-0.057315,-0.024621,0.015867,-0.014276,-0.054135,0.016508,0.060295,-0.004164,-0.046962,0.001499,-0.009123,0.051765,-0.008582,0.058709,-0.060882,0.022092,0.016664,-0.033656,0.024122,0.015893,-0.034332,0.013769,0.045374,-0.022761,0.027210,-0.019566,-0.043280,0.014175,0.054545,0.008755,0.060197,0.060112,0.037760,-0.014744,-0.054046,0.007221,-0.003270,0.018674,0.033666,0.000006};
  parameter real W2149[0:249] = {0.039001,0.046345,0.039394,0.006414,-0.027063,0.040050,0.019882,-0.029932,-0.036475,0.016306,-0.015823,0.004598,0.060039,-0.044153,0.028183,0.009997,-0.027050,0.011890,0.062107,0.035048,0.048349,-0.021182,0.007116,-0.054302,-0.029022,-0.016567,0.034824,-0.027264,0.040809,0.006154,-0.046731,-0.058792,-0.004783,-0.033070,-0.013305,0.006034,0.018859,0.026250,0.047825,0.037009,0.003039,-0.048622,0.005128,0.014534,0.009828,0.042821,0.047274,-0.057419,-0.010451,-0.005709,-0.036182,0.032936,0.019920,0.058507,0.050507,0.055255,0.017849,-0.021562,0.065216,-0.043915,0.017918,0.041371,0.051310,0.035550,-0.014035,-0.058555,-0.038842,-0.054691,-0.011856,0.041542,-0.048376,0.035159,0.062255,0.011130,-0.068192,-0.016839,-0.039999,-0.001231,-0.035975,0.016873,-0.057551,-0.017869,-0.030454,-0.034617,-0.059984,-0.003535,-0.017077,-0.052912,0.058126,-0.054250,-0.044510,0.013934,0.064562,-0.042760,0.031274,0.036958,-0.040830,-0.032186,0.057227,-0.001051,0.010573,-0.041217,-0.063951,0.008620,-0.015285,0.048410,-0.039078,0.025051,0.051102,-0.013907,0.018180,-0.064279,0.003656,-0.006585,0.020911,0.055967,0.031076,-0.051755,-0.010199,0.002888,0.026170,-0.028166,-0.049128,0.058892,0.054376,-0.065491,-0.014647,-0.007925,0.019844,-0.058877,-0.012143,0.050808,-0.057603,-0.015367,0.057817,0.059909,0.008256,0.043666,0.026050,0.043635,0.004040,0.019059,-0.017661,0.041156,0.026764,-0.034204,0.043680,0.049533,0.017069,0.010412,0.051006,-0.002132,-0.001806,0.006580,-0.047582,-0.009361,-0.004370,-0.043734,-0.034365,0.037097,-0.021709,-0.055701,-0.006252,-0.058018,-0.049576,0.042149,-0.040285,0.008683,-0.025005,0.039272,-0.057861,-0.008709,-0.043140,0.034809,-0.019071,-0.019806,-0.006827,0.022390,0.058075,-0.029585,0.063120,0.019326,0.027449,0.046253,-0.029643,0.000280,0.050771,-0.054068,-0.030873,0.060306,-0.017084,-0.031371,-0.055637,0.034078,0.012764,-0.030859,0.029816,-0.046039,-0.047310,0.037068,-0.051182,-0.007623,0.061053,-0.049112,-0.000349,0.017281,-0.002945,-0.034550,-0.038564,-0.054100,-0.011518,-0.002987,0.022840,0.007071,0.038119,-0.035611,0.036108,0.002186,-0.055779,0.004608,-0.026978,-0.018118,0.051915,-0.002455,-0.043896,0.015589,-0.031373,0.050163,0.029634,0.015871,-0.011912,0.038253,0.059669,0.007439,-0.019937,0.065580,-0.008463,0.006391,-0.011871,-0.033528,-0.069435,-0.020829,0.031240,0.000013,0.063623,-0.047164,-0.004600,-0.004196,-0.040049,0.047350};
  parameter real W2150[0:249] = {-0.001449,-0.011040,0.052229,-0.033153,-0.031791,-0.040609,0.015889,0.053124,0.021152,-0.053622,0.007177,0.054655,0.044233,0.068182,-0.043556,0.034103,0.002535,0.045255,-0.054862,-0.047754,-0.027171,-0.022436,0.046076,0.019387,0.006950,-0.060490,-0.035047,-0.042369,0.061523,0.027194,-0.058389,0.035497,0.054702,0.049701,0.057343,-0.051658,-0.044941,0.008480,-0.030813,-0.023732,0.015336,-0.040662,0.059821,-0.045605,-0.008674,-0.040224,-0.064713,0.050433,0.045580,0.004624,0.036513,0.053613,0.054589,-0.029220,0.051032,0.045597,0.029399,-0.013079,0.023643,-0.025367,0.044117,0.055236,0.038909,0.052577,-0.029425,-0.016395,-0.014474,-0.011094,-0.056334,0.059123,-0.026912,0.037258,0.032079,0.063159,0.025539,-0.031233,0.008619,-0.062919,-0.012505,0.027032,0.038194,0.003559,0.012451,-0.019795,0.013445,0.017997,-0.036888,0.034815,0.011669,0.043089,-0.006111,0.059461,0.019846,-0.062235,0.051223,0.006964,-0.032777,0.054936,0.005509,-0.036283,0.053150,-0.020986,0.000642,-0.055802,0.008379,0.022924,-0.040918,0.011849,-0.016190,-0.001475,-0.057568,0.046550,0.020259,-0.009477,0.025392,0.024773,-0.048156,0.049869,-0.013842,-0.001031,-0.021578,0.044201,0.061628,0.021205,0.041597,0.009615,-0.032013,0.022054,-0.002543,-0.034500,-0.050865,0.009025,0.015944,-0.008067,-0.023260,0.022234,-0.003091,0.031516,-0.009961,0.014528,0.050813,0.035718,0.047808,-0.063116,-0.054362,-0.000399,0.011205,0.049026,0.009821,0.022352,0.050044,-0.058488,0.003691,0.033566,0.002532,-0.032134,-0.032535,0.046815,-0.016596,0.038904,0.018007,0.049001,0.026277,0.045270,0.014229,0.000440,-0.028734,-0.022908,-0.063592,0.011959,0.040931,-0.011180,-0.040999,-0.046348,-0.017646,-0.029615,-0.020623,-0.001859,0.055618,-0.021457,0.014496,-0.034124,0.015038,-0.049582,-0.058167,-0.052398,0.044537,-0.034017,0.024207,-0.004932,0.033891,0.047457,0.027216,-0.003382,0.043251,-0.020642,-0.028970,0.001679,0.042216,-0.036459,0.058386,-0.060525,-0.044849,0.017858,-0.042670,-0.009266,-0.061268,-0.040517,-0.059447,0.019511,0.010155,0.023164,-0.054990,0.058737,0.036148,0.032297,-0.020789,0.047608,-0.055040,-0.004228,-0.060983,0.007719,-0.011115,0.006375,0.000128,0.025435,0.010863,-0.034690,0.019203,0.064353,0.035055,0.038297,0.059612,0.005479,0.004192,0.046752,-0.055244,-0.010709,-0.048529,-0.007841,-0.040279,0.008499,-0.005687,-0.056198,0.017793,0.039526,0.037768,-0.001771,-0.050287,-0.051582};
  parameter real W2151[0:249] = {0.011591,-0.065901,0.048954,-0.023889,0.024461,0.027510,-0.035873,0.030601,0.050764,-0.069926,-0.056432,0.004149,0.056340,0.010811,-0.016401,0.039955,-0.005223,0.039893,0.023972,0.019968,-0.003214,-0.075294,-0.017474,-0.051357,-0.032286,0.030709,0.050369,-0.021120,-0.000148,0.012807,-0.050740,0.030319,0.031044,-0.035328,-0.001788,-0.016465,-0.003848,0.032237,0.065798,0.013064,0.023209,0.064736,-0.021711,0.009545,0.038560,-0.057029,-0.030097,-0.036693,-0.023339,0.076241,-0.010647,-0.051935,0.037594,-0.000181,-0.051784,0.039312,0.040873,0.010060,-0.002945,-0.035699,-0.064538,-0.060145,-0.048140,0.019441,-0.012320,0.020682,-0.067739,-0.018798,-0.059249,0.001557,0.033424,0.035220,0.032029,-0.013083,0.013462,0.012466,0.018595,-0.046296,-0.033449,0.027208,-0.022312,0.043586,-0.018436,0.065277,-0.003221,-0.063982,0.000890,-0.070971,-0.037942,0.020941,-0.036237,0.011319,-0.022110,0.067081,-0.054487,0.021470,-0.017602,-0.033866,0.026628,0.017219,-0.047073,0.054247,0.010493,-0.022624,-0.042118,0.000865,-0.039190,0.005429,-0.022394,0.064427,0.003504,-0.008382,-0.014235,0.053695,-0.051787,-0.048442,-0.052623,0.049715,0.016971,0.011569,0.063228,0.009121,-0.018119,0.003293,0.014652,-0.033855,0.052750,-0.032476,0.043650,0.053801,-0.029048,-0.013020,0.050584,0.023237,-0.001207,-0.058848,0.040163,0.031846,0.065801,0.020442,-0.045784,-0.028236,0.024019,-0.016691,-0.032091,-0.022243,-0.023522,-0.045840,-0.013854,-0.026136,0.050098,-0.057898,-0.036898,-0.015376,-0.042184,0.053737,-0.044268,-0.006571,0.052929,-0.007227,0.045130,0.029633,0.039096,0.002092,0.034021,-0.064090,0.011759,0.029768,0.037904,0.025867,0.050950,-0.042232,-0.040118,0.010707,0.017304,-0.031613,0.006534,-0.005832,0.032087,-0.018988,0.005054,-0.025631,0.029416,-0.039085,0.040935,-0.020917,0.032068,0.027225,0.064319,0.055897,0.061664,0.013258,-0.047267,-0.002929,0.004402,-0.040021,-0.054243,0.018048,0.015718,-0.009590,-0.064391,0.040057,0.054083,0.045093,-0.056027,-0.047441,-0.050122,0.031265,-0.036174,-0.043892,-0.078060,0.068447,0.024188,0.047562,0.048732,-0.027095,-0.036908,-0.061479,-0.007965,0.016584,-0.062036,-0.011737,-0.017244,-0.020793,0.029916,0.028020,-0.049545,-0.004309,-0.045185,-0.021461,0.068035,-0.017397,0.046174,-0.014258,-0.059989,-0.051307,-0.022023,-0.053131,-0.016507,-0.010509,-0.025407,-0.062802,-0.025484,-0.003233,-0.050378,-0.035582,0.061709,0.068711,0.057222,-0.052113};
  parameter real W2152[0:249] = {0.014711,-0.056878,-0.031141,0.055450,0.059077,0.059502,0.017008,-0.050782,0.005893,0.050137,0.050861,-0.041360,-0.046567,-0.001740,0.043236,0.044651,-0.007417,-0.019255,-0.058430,-0.004706,-0.039114,0.012238,0.054650,0.036892,-0.039064,-0.033478,-0.052014,-0.055905,0.057980,-0.051550,-0.053708,0.034360,0.055045,0.030167,-0.057262,0.031323,-0.025079,-0.064360,-0.050872,-0.006459,-0.030145,0.030542,0.034818,-0.050801,0.025882,-0.052434,0.005202,0.008398,0.054600,0.005938,0.064862,-0.026118,0.002059,0.019111,0.011366,0.024063,0.008017,-0.008503,0.039547,-0.044848,0.048753,0.044705,0.017635,-0.000854,-0.029449,0.021270,0.059577,-0.050246,0.031675,-0.000535,-0.013394,-0.057856,-0.018367,-0.002409,0.043542,-0.049081,-0.063517,0.055510,-0.036620,0.061202,0.046061,0.025620,-0.038084,-0.033622,-0.055375,0.035712,0.058815,-0.054587,0.023757,0.009137,-0.064279,0.009179,-0.012908,0.054009,-0.054109,-0.006313,-0.001590,-0.051411,0.036569,0.037693,0.032703,0.026096,-0.057059,-0.036508,0.061127,-0.004113,0.032266,0.049854,0.008821,0.036612,0.054995,-0.053322,0.036931,-0.007246,0.013437,0.013260,0.001563,-0.003582,0.058680,-0.039456,-0.042930,-0.003196,-0.004847,-0.019935,0.038942,-0.018488,0.001947,0.007226,0.053473,0.028388,0.053485,-0.013113,-0.058291,-0.048742,-0.024703,-0.028519,0.000530,0.045170,-0.059306,0.015062,0.059214,0.020556,0.033122,-0.055291,-0.056305,-0.045501,-0.020736,-0.011388,-0.013714,-0.015735,0.033538,0.020458,0.007446,0.005536,0.003385,0.045961,-0.043767,0.010204,-0.038691,0.046474,0.038842,0.015288,-0.064416,0.054852,0.058464,0.020754,-0.034278,-0.030111,0.001199,-0.028486,0.008773,0.036820,0.038480,-0.025506,0.000524,-0.011611,0.016759,-0.021067,-0.052747,-0.020676,0.029661,-0.033542,0.059843,-0.001781,0.044314,-0.055161,-0.018776,0.047196,-0.026497,0.010410,0.006859,-0.002112,0.024403,-0.044285,-0.019286,-0.039013,0.001481,-0.018724,0.053579,-0.030452,0.057798,0.057721,-0.038844,0.012448,0.047619,0.003170,-0.043105,0.017946,-0.021708,-0.026552,0.027030,-0.051215,-0.026548,-0.036078,-0.066147,-0.035074,0.038966,-0.054573,-0.020089,0.020647,0.003862,-0.003873,-0.049939,0.061649,-0.055265,0.052926,0.044436,-0.002029,0.016544,-0.058531,0.057339,0.000171,-0.051148,0.014465,0.019455,-0.012597,0.024245,-0.031363,0.010135,0.010620,0.012590,0.039372,0.003898,-0.054224,0.041418,-0.032932,0.016251,-0.047406,-0.053428,0.024320};
  parameter real W2153[0:249] = {-0.057812,0.043529,0.057495,0.057332,-0.045966,-0.047675,-0.023174,0.002904,0.047384,0.052930,-0.052124,0.008755,-0.043055,-0.059017,0.029205,-0.027389,0.012716,-0.023397,-0.029578,-0.035223,0.040447,0.007247,0.053508,0.038600,0.038785,-0.037269,0.042346,-0.049066,0.050018,0.031015,-0.007145,0.059054,-0.043789,0.032697,0.042864,0.018475,0.037067,-0.060258,-0.056837,-0.037293,-0.032784,-0.034548,0.052266,0.031954,-0.044891,0.018382,-0.056123,-0.028204,0.038167,0.052881,-0.004547,0.016460,0.054931,-0.043467,0.056580,-0.009652,-0.039939,0.025037,-0.008602,-0.035459,-0.034801,0.052009,-0.026809,-0.029476,0.036033,-0.017799,0.040075,-0.010425,0.037159,0.042192,-0.026572,-0.041750,-0.034969,-0.038294,-0.027086,0.063166,0.016591,-0.007627,0.060955,-0.002896,0.029965,-0.044300,-0.061329,0.022431,0.007280,-0.060843,0.034841,0.000062,-0.024529,0.040571,-0.028310,0.037643,0.060587,0.021637,-0.061399,-0.009618,0.029210,-0.057199,-0.007646,-0.061637,-0.027521,0.024789,-0.047898,0.050832,-0.008468,-0.034015,0.039444,-0.054473,0.006953,0.034947,-0.001063,0.003367,-0.027462,-0.062164,-0.024636,0.006664,0.020684,0.032469,0.022964,0.034167,-0.007109,-0.038980,0.033998,0.026280,-0.044663,-0.006684,0.060669,-0.060809,-0.000072,0.011660,-0.045729,-0.047682,0.058057,0.051689,-0.049725,-0.019536,-0.046389,0.028399,0.041807,0.032497,-0.029003,-0.031189,0.009815,0.000888,0.056496,0.028298,-0.003750,0.017285,-0.022142,-0.043282,-0.010997,-0.001043,-0.041206,0.062590,-0.040581,0.059360,0.019613,0.020326,-0.006864,-0.041841,0.059160,0.021853,0.045845,0.054179,0.020839,-0.002830,-0.033869,0.023368,0.012776,0.021745,-0.018684,-0.037795,-0.002531,0.032811,0.061889,-0.027789,0.017814,-0.054744,-0.054484,0.022347,0.033759,0.054922,-0.005161,0.002655,0.008511,-0.052530,0.005909,0.038435,0.055842,-0.013644,0.033285,0.059911,-0.019178,0.033565,0.027875,-0.052752,-0.014794,0.031658,0.004431,0.061924,0.013768,0.055871,-0.019598,-0.026240,0.024529,0.060726,0.042267,-0.026194,0.000226,-0.055651,0.049263,-0.061915,-0.061588,-0.015507,-0.049871,0.026167,0.055416,0.017584,0.052469,0.001698,0.003768,-0.003539,0.050969,-0.046463,0.019388,-0.018743,0.002481,0.013530,-0.011156,0.022899,0.047218,0.015291,-0.011082,0.045916,0.048074,-0.027052,-0.000374,0.004805,-0.007034,0.044104,0.011068,0.056180,0.004774,0.040284,0.004331,-0.044381,0.021367,0.041384,0.048601,0.035032};
  parameter real W2154[0:249] = {0.001941,0.013495,0.012158,-0.053020,0.006534,-0.063516,-0.025789,-0.019343,-0.061720,-0.061668,-0.036105,-0.029389,0.062434,0.000988,0.037044,-0.059618,0.050900,-0.047900,0.027570,0.024576,-0.051434,0.043313,-0.033129,-0.017326,0.044615,-0.063897,-0.012082,-0.062374,-0.041350,0.062724,-0.003564,-0.012332,-0.031418,-0.033727,0.050747,0.025157,-0.000882,0.022815,0.013187,0.053788,0.052260,0.021008,-0.017728,0.048600,0.044942,-0.065858,0.014966,0.001776,-0.020453,0.021081,-0.046562,-0.006242,0.062741,0.058177,0.033287,0.061312,0.021445,-0.058440,0.045237,-0.038713,0.012488,-0.029249,-0.012693,-0.024213,-0.065402,0.002121,0.017203,-0.019018,0.029483,-0.029705,-0.043564,-0.042608,0.064217,0.035698,-0.052702,0.041087,0.017416,-0.045641,-0.032797,0.026684,0.028257,0.027891,0.032450,-0.052586,-0.047400,0.055038,-0.057838,0.049257,0.010209,-0.045190,-0.054792,-0.014141,0.023506,0.024366,-0.045708,0.017644,-0.060751,0.003753,0.013612,-0.037709,0.047721,0.002947,-0.031796,-0.045255,0.041852,0.050455,-0.067013,-0.026389,0.057612,-0.058437,0.001059,-0.041964,-0.007444,-0.023596,-0.031651,0.040182,-0.047634,0.019730,0.036144,0.030917,0.050465,-0.031137,0.035706,0.003165,0.039428,-0.042794,0.026629,0.010304,0.062915,-0.009011,-0.027093,0.050712,-0.049816,0.014951,-0.007834,-0.034983,-0.009215,0.060943,-0.040293,-0.030716,-0.036813,0.050025,0.020185,0.028047,0.038622,0.036378,0.061079,0.027239,-0.049288,0.014867,0.059346,0.026956,-0.027423,0.001287,-0.051466,0.060038,0.035815,0.020596,-0.014736,-0.046238,0.003586,-0.020505,0.030657,-0.005424,-0.060066,-0.035912,-0.005142,0.056101,-0.008492,0.020276,-0.018433,-0.061507,0.015992,-0.033150,-0.015413,0.026400,0.044082,-0.019094,-0.056406,0.001841,-0.044007,0.001663,0.062298,-0.003388,-0.032961,-0.026090,-0.002486,0.028406,0.039785,0.051210,-0.039536,0.045029,0.017252,-0.013346,0.063460,-0.034831,0.014654,0.021024,0.062093,0.019767,0.017225,-0.015523,0.044986,-0.026011,-0.004165,-0.051649,0.047177,-0.002292,-0.024414,-0.031827,0.023662,0.028425,0.057888,-0.017939,0.065095,0.036138,0.043682,-0.022689,0.055366,0.010942,-0.042134,0.040828,0.018799,0.008090,-0.020538,0.002018,0.047654,-0.017696,-0.005525,0.037535,-0.021642,-0.063357,-0.058100,0.033526,0.003234,-0.029665,0.040665,-0.046003,-0.052324,0.046610,-0.046140,-0.024033,-0.039810,0.050775,0.051283,-0.019268,-0.030622,-0.048415,0.036878,0.040642};
  parameter real W2155[0:249] = {-0.045616,-0.034912,0.031207,0.020130,0.011646,-0.000302,-0.040867,-0.001943,0.017457,0.013263,-0.062554,-0.015560,-0.047538,0.000157,0.028529,0.052612,0.025623,-0.019529,0.060211,0.023719,0.009846,-0.024562,0.034957,0.006787,0.002412,-0.055840,0.010968,-0.010148,-0.001947,-0.009656,-0.028801,0.002487,0.030946,-0.034306,0.058728,-0.002874,-0.001512,0.049006,0.058842,-0.052868,-0.021143,-0.031441,0.059581,0.050634,-0.021975,-0.055509,0.045911,0.017398,0.031724,-0.030757,0.023006,-0.043826,0.011393,0.042496,-0.042048,-0.004260,-0.035118,-0.000855,-0.054692,-0.008858,0.008126,-0.008723,-0.004651,0.019088,-0.004508,-0.027486,0.040866,0.014975,-0.044698,-0.034438,0.044048,0.003644,0.018410,-0.009149,-0.012570,0.037330,-0.058418,-0.046347,0.006259,0.034572,-0.055108,-0.063468,0.043977,0.077551,0.027266,0.041999,-0.046167,0.048831,-0.050872,-0.002356,0.021735,0.012239,-0.027918,-0.044066,0.032564,0.053517,0.022310,-0.050688,0.051482,0.043517,0.009649,-0.054979,0.031956,0.008438,-0.031950,0.041770,0.003885,-0.053994,0.035086,0.002789,0.051931,0.004139,0.051501,-0.023406,0.030887,-0.031922,-0.049554,-0.040131,0.004653,0.007102,0.062873,0.039021,0.061440,0.021733,-0.026943,-0.043117,-0.043535,-0.015441,0.035843,0.060493,-0.031633,0.021308,0.030871,-0.034463,0.038316,0.053200,-0.016003,0.007487,0.001892,-0.002358,0.027953,-0.057896,0.031433,0.048453,0.065340,-0.046782,0.052080,0.011263,-0.015006,-0.009621,-0.033238,-0.066382,0.060472,0.036593,0.051274,-0.052487,0.006224,0.049036,0.035186,-0.045753,-0.011709,-0.031783,-0.041715,0.027652,-0.026798,-0.043020,-0.029181,0.041018,0.008570,0.032967,0.012811,0.013590,0.054345,-0.016870,-0.037993,-0.046964,-0.037722,-0.041781,-0.021195,0.015367,0.059506,-0.044293,0.040422,-0.047954,0.045760,-0.039563,0.021504,-0.044606,0.005864,-0.026857,-0.014134,-0.045060,0.055512,0.058738,-0.036489,-0.041460,0.019528,-0.022420,0.059246,0.020985,-0.016386,0.007359,-0.054528,0.020073,0.062848,0.032499,-0.031468,0.008917,-0.025849,-0.039082,0.041810,0.044773,0.052901,0.018373,0.059864,0.001718,-0.048070,0.056937,0.029493,-0.014591,-0.002021,0.022440,-0.038562,-0.056506,-0.047812,-0.010661,0.040573,-0.054380,0.061906,0.060139,0.011256,-0.055914,0.005484,-0.038714,0.012244,-0.027743,-0.052166,0.008802,0.046708,-0.027202,-0.023053,-0.057068,-0.019217,0.025503,-0.048821,-0.003286,-0.004736,0.039719,-0.019208,-0.054134};
  parameter real W2156[0:249] = {0.012246,0.039542,-0.041480,-0.024117,0.014662,0.001165,0.008536,0.050063,-0.003397,-0.062354,-0.027691,0.057338,-0.011213,-0.012761,-0.042312,0.051223,0.057381,0.020865,0.031513,-0.004781,0.021896,0.010982,0.014911,0.045406,0.064701,-0.015404,-0.023541,-0.002642,0.041527,-0.054288,0.055989,0.046291,-0.049266,0.008568,-0.020881,-0.029587,-0.021794,-0.000097,0.025262,0.045529,-0.025303,0.029378,0.019311,0.056380,0.008103,0.036145,0.035137,0.013018,0.022548,0.064365,-0.030901,-0.042235,0.060816,0.010957,-0.003561,-0.010874,-0.041629,0.030238,-0.031249,-0.011235,-0.029513,0.034644,0.050248,-0.006037,-0.031319,-0.045555,0.051202,-0.058394,-0.004540,0.020118,-0.057704,0.001903,0.028488,-0.027046,-0.026488,0.076983,0.024814,0.014592,-0.022886,0.025785,0.001817,0.053269,0.029465,0.007320,0.034867,-0.040968,0.066363,-0.053843,0.032261,-0.012200,-0.049837,0.045444,0.058181,-0.052904,-0.021704,0.064941,-0.025482,-0.048624,-0.048005,-0.008382,-0.044153,-0.015701,0.057472,-0.017406,-0.054571,-0.041636,-0.035224,0.012941,0.067168,-0.015070,0.023783,-0.026252,0.050543,-0.027363,-0.004690,0.003187,-0.063960,-0.055658,-0.011758,-0.001743,-0.044089,-0.037409,0.038430,0.010835,0.039232,0.047718,0.039366,-0.029315,0.036664,-0.007118,0.063780,-0.023108,0.052760,-0.009088,-0.037307,-0.010156,0.026678,0.004591,0.011568,0.025039,-0.066737,-0.055588,0.046766,-0.053347,-0.059113,-0.005153,0.065136,0.028291,-0.020603,0.037780,0.038655,-0.061360,-0.030162,-0.033926,0.033389,0.000925,0.018399,0.008315,-0.018327,-0.027111,-0.034794,0.030295,0.037733,0.007765,-0.034095,-0.066695,0.038903,-0.035286,-0.064773,-0.023370,0.050487,0.017589,0.026710,-0.033503,0.050656,-0.020524,-0.027513,-0.053509,0.021538,-0.048324,-0.059605,0.003575,0.052038,-0.020649,-0.014392,0.038989,0.027905,-0.061699,-0.019542,-0.025192,0.027705,0.026737,0.007447,0.013484,0.054432,-0.032632,0.046458,0.003269,0.028615,-0.039635,-0.013078,0.040486,-0.052764,0.021575,-0.033071,-0.021382,-0.030035,0.012243,-0.049501,0.054112,-0.008518,0.036979,0.056440,-0.038648,0.033132,0.071607,-0.062534,-0.043924,-0.051916,-0.011580,-0.008318,0.065785,0.046109,-0.025789,-0.032690,-0.052904,-0.034760,0.016801,0.056929,0.062576,0.003021,-0.005849,-0.040013,0.041752,0.035379,0.003031,-0.018114,0.053894,0.054286,-0.026824,0.051216,-0.056903,-0.035001,0.053128,0.055802,-0.036222,-0.055051,0.055617,0.018595,-0.013168};
  parameter real W2157[0:249] = {-0.045693,0.041059,-0.041708,-0.041580,0.046020,-0.045088,-0.047622,-0.055996,-0.048334,0.067771,-0.019357,0.018910,-0.055928,-0.013240,-0.031368,0.016191,-0.046743,-0.022525,-0.020095,-0.031325,-0.034622,0.017864,-0.047099,0.055920,-0.006076,0.009886,0.003729,-0.036075,-0.041459,-0.016136,-0.022828,-0.015540,0.040814,0.053394,-0.091381,0.034188,0.044016,-0.029909,0.018108,0.033905,0.051039,-0.047417,0.003346,0.060067,-0.000217,-0.028432,-0.048696,0.007838,-0.041328,-0.018631,-0.035268,-0.049546,0.031998,-0.003985,-0.036683,-0.044993,-0.058447,0.047720,-0.019255,-0.038060,0.045596,0.052713,0.000505,0.023802,-0.043309,0.017164,-0.003275,-0.039959,0.015823,0.018971,0.058841,-0.027101,0.038255,-0.063497,0.015184,-0.007920,0.019826,0.018625,-0.027285,0.027498,-0.039425,-0.013690,-0.005783,0.027392,0.047280,0.015257,-0.044770,-0.035798,-0.063981,-0.050204,-0.028771,-0.000722,0.031927,0.027445,0.034270,-0.047911,0.055792,0.065444,0.016929,-0.008738,0.066789,-0.055570,-0.050234,0.054898,0.055446,-0.032709,-0.018509,0.019662,-0.059468,-0.013700,0.023935,-0.006947,-0.011462,0.040306,0.019538,-0.042031,0.025354,-0.053777,-0.008955,0.036593,-0.036576,-0.042038,0.029157,-0.024843,-0.056265,-0.035602,-0.008341,0.011892,0.012861,-0.053261,-0.008614,0.048826,-0.049421,-0.022987,-0.018954,-0.067004,-0.045438,0.030259,0.045317,0.019644,-0.015846,-0.007082,0.032095,-0.006973,-0.023514,0.007559,0.015150,-0.034444,0.005868,0.035398,0.047560,0.073005,0.019203,0.058444,-0.025903,-0.038727,-0.011781,-0.021945,-0.003355,-0.014090,-0.039933,0.025423,-0.061883,0.020466,0.049460,0.054677,-0.052187,-0.032217,0.007580,0.055398,-0.041547,0.044767,0.029736,0.068237,0.036898,-0.023655,0.009588,-0.061413,-0.048333,0.056338,0.011763,-0.029746,-0.029887,-0.016788,-0.034578,0.024415,0.005622,-0.034515,-0.026748,0.026934,0.003042,-0.026643,0.004454,-0.000111,-0.061590,-0.055342,0.055205,0.005255,0.001242,-0.022056,0.025815,0.001913,0.027834,-0.038313,0.003225,0.047487,0.063076,0.017173,0.057528,-0.058792,0.051872,0.007943,0.024024,-0.010381,-0.016971,-0.012457,-0.005383,-0.053395,-0.028445,-0.013635,0.038668,-0.033260,-0.062026,-0.054262,0.060706,-0.052228,-0.029836,-0.060301,-0.022110,-0.062716,-0.058721,-0.004819,0.059709,0.061249,0.008618,-0.062048,-0.031686,0.037190,0.008824,-0.060641,-0.015681,0.003318,-0.039334,0.017580,0.032910,0.043639,-0.042414,0.014523,0.018449,-0.002594};
  parameter real W2158[0:249] = {-0.027953,-0.002677,-0.059680,-0.058986,-0.014034,0.030989,0.060805,-0.053333,-0.044787,-0.048499,0.012089,0.017295,-0.050389,0.041871,0.016517,-0.006166,0.051057,0.013969,0.047016,-0.036041,0.024278,0.048699,-0.037832,-0.053712,-0.004379,0.016761,-0.059746,-0.005327,-0.017413,0.026660,0.028806,-0.019656,0.064098,0.033993,0.030943,0.033717,0.013140,-0.056890,-0.053422,-0.039761,0.045720,0.012183,-0.057448,-0.017526,0.004475,0.041633,0.054726,-0.057987,-0.055736,0.006244,0.028644,-0.054556,-0.021515,-0.060146,0.060682,-0.053567,-0.031262,-0.021366,-0.028692,-0.052794,0.004219,0.041735,0.041765,0.039318,0.033040,-0.033496,-0.038259,0.020483,0.012379,0.044914,-0.006031,0.063104,0.040741,0.045221,-0.001972,-0.049286,0.005124,0.003671,0.021520,-0.044158,0.023929,0.038211,-0.037361,-0.038198,-0.010795,-0.002009,0.011357,-0.028623,0.032431,0.044260,0.018782,0.048043,-0.022871,-0.026838,-0.031397,0.037388,-0.012928,0.027784,-0.049716,-0.024619,0.015281,0.002377,0.023605,0.049777,0.049321,-0.052565,-0.024965,-0.039722,0.006324,0.032193,0.003087,-0.053064,0.052655,0.029053,-0.031263,0.057402,0.010551,-0.028234,-0.028345,-0.037275,0.019468,-0.017526,-0.023988,-0.005288,-0.047771,-0.016427,-0.058082,0.003569,-0.017177,0.054720,-0.055126,-0.019461,-0.036287,-0.011461,-0.017960,-0.006995,-0.034431,-0.022664,0.006730,-0.014513,-0.050156,0.053809,-0.030990,0.038285,-0.011618,-0.058250,0.013436,0.057380,0.044521,0.024289,-0.014826,-0.054982,0.010935,-0.037514,-0.046422,-0.010114,0.035898,0.046025,-0.028932,-0.016285,0.045084,0.043730,0.009501,0.029268,0.017792,0.015483,0.061866,0.040691,0.022324,-0.032241,0.021146,0.003829,-0.041878,0.022850,0.023113,-0.058678,-0.030155,0.039506,-0.017342,-0.019045,0.021570,0.038732,0.002740,0.058102,0.051897,0.034181,-0.063016,-0.047992,0.024312,-0.005233,0.052704,-0.055502,-0.031105,0.009309,-0.047836,0.041006,0.023882,-0.002427,0.035677,-0.043069,-0.048663,0.043147,-0.018420,0.049922,-0.039715,-0.037818,-0.014001,-0.043169,-0.026296,-0.045019,0.011466,-0.034342,-0.036427,-0.028194,0.049691,-0.055909,0.040141,-0.030676,0.015985,-0.033403,0.050418,0.052411,0.053409,-0.061210,0.012134,0.000252,0.027916,-0.051967,-0.050173,0.042368,-0.006554,-0.065130,0.017601,0.018303,0.064245,0.044261,0.050513,-0.018089,-0.062296,0.021669,0.060480,-0.014157,0.002504,0.010190,0.025690,0.041285,0.002553,-0.034433,0.027276,-0.042752};
  parameter real W2159[0:249] = {-0.013288,-0.010790,0.019293,-0.017413,0.020368,-0.022377,-0.004809,-0.027603,-0.055443,0.023920,0.057748,0.011010,-0.020041,-0.005475,-0.002738,-0.045971,0.003396,-0.013853,0.051507,0.007176,0.040709,0.061717,0.022579,0.011276,-0.016131,0.052971,-0.010623,0.006011,0.004417,0.041119,0.009046,-0.042262,0.062596,-0.043430,0.007783,0.000458,-0.031148,0.021047,-0.029690,0.000043,0.055917,0.057234,0.036365,0.036676,0.007093,0.013196,0.040702,-0.036868,-0.006418,-0.044079,0.065554,0.003811,0.004419,0.041221,-0.051105,0.004514,0.033870,-0.001898,-0.062548,0.005356,-0.047074,-0.029709,0.043251,-0.044740,-0.040535,0.001830,0.036981,-0.038523,0.051572,0.023805,-0.015996,0.001377,0.038790,0.025388,0.015500,-0.050532,-0.030536,-0.013394,0.008373,0.004196,0.058567,-0.018842,-0.025952,0.001210,-0.015821,0.045844,-0.044193,0.012364,0.016161,0.046966,-0.026630,-0.015661,-0.061806,-0.007116,-0.041962,-0.065251,-0.019504,0.043145,0.031399,0.016053,-0.024057,-0.041234,0.011959,0.052983,0.012296,0.040696,0.057055,-0.011551,0.032241,-0.033241,-0.054571,0.041636,-0.005711,-0.040742,0.029903,0.043456,-0.026984,0.007050,0.015074,0.009249,0.012963,0.006711,0.040638,-0.028477,-0.055637,-0.055441,0.016481,-0.029498,-0.029655,-0.047532,-0.017751,-0.045840,0.009810,-0.034944,-0.054581,-0.063889,-0.027616,0.013389,0.040448,-0.044532,0.059616,-0.057121,0.048147,0.028427,-0.031849,0.044320,-0.036567,-0.043743,0.022970,0.041644,0.038286,-0.021382,-0.049768,-0.008545,0.059149,-0.002182,-0.035990,-0.050433,0.059883,-0.036652,-0.024613,0.046734,0.013466,-0.047253,0.022123,-0.001079,0.053988,0.032042,0.023420,-0.007195,-0.004495,0.022595,-0.004434,-0.028332,-0.051956,0.017873,0.022690,0.025127,-0.067198,-0.012902,0.033690,-0.022155,0.043991,0.009226,-0.037361,-0.017234,0.035066,-0.019790,-0.044224,-0.050160,0.047695,0.054167,-0.014281,0.030362,-0.043073,0.063193,0.018737,-0.002977,0.025547,-0.032419,-0.038270,0.004861,-0.049395,-0.037549,-0.045467,0.013777,-0.050355,0.030432,-0.024968,0.045140,0.064720,-0.038064,0.058239,0.015706,-0.048813,0.013329,-0.056653,0.039340,0.001597,-0.030347,0.046828,0.058651,0.037896,-0.046788,-0.029809,-0.004946,0.021687,0.042463,0.016203,-0.012742,0.046614,-0.011397,-0.044283,0.037699,0.049041,-0.015895,0.001902,0.026387,0.053350,0.001025,0.064670,-0.053527,0.046849,-0.055441,-0.028486,-0.028019,-0.035016,0.000609,0.025151,0.043555};
  parameter real W2160[0:249] = {-0.010919,-0.060621,0.049068,0.003553,0.058389,-0.045196,-0.043572,-0.027799,-0.039966,-0.040183,0.007251,0.007261,-0.032067,-0.020211,0.030358,-0.015532,-0.025311,0.038551,0.036862,-0.027043,0.006853,0.001443,-0.006492,-0.065700,0.055625,-0.059977,-0.014161,-0.041807,-0.007870,0.057188,-0.021961,-0.046895,-0.046164,-0.056097,0.082123,0.013565,-0.058172,0.050479,-0.055565,0.039782,0.007128,-0.019630,-0.013897,0.001609,0.049300,-0.034856,0.029148,0.033010,0.021509,0.017545,0.022108,0.019048,0.067629,-0.049720,-0.017055,-0.042380,-0.041438,-0.039475,0.026943,-0.006573,-0.043056,0.058408,0.011707,-0.035794,0.056583,-0.055702,0.067467,0.042150,-0.011199,-0.011066,-0.004093,0.009946,-0.056593,0.011412,0.001914,0.035688,-0.018512,0.036898,-0.038112,-0.053591,0.031551,-0.038964,0.016688,0.071226,-0.034130,0.020806,-0.077226,-0.022700,0.056659,-0.024635,-0.019337,0.028931,0.015161,-0.051087,0.030597,-0.003591,-0.008373,-0.035872,0.039589,0.005939,-0.001671,-0.012542,0.038326,-0.006591,0.043656,0.026130,-0.083587,-0.046809,-0.008379,-0.012160,0.003752,0.031042,-0.060823,0.034315,0.016697,-0.051217,-0.043827,0.045615,-0.062117,0.006042,0.014322,0.025907,-0.018314,0.027083,-0.009436,-0.068426,-0.061242,0.018225,0.022155,-0.029319,-0.001836,0.025292,0.053401,0.056634,0.033847,-0.031446,-0.040441,0.022936,0.021066,0.019420,0.039875,0.063735,0.018858,-0.001820,-0.032569,0.003503,-0.005471,-0.007914,0.003082,0.001623,0.044238,-0.039269,-0.032583,0.012750,-0.021794,0.005268,-0.038986,-0.046674,-0.044662,0.017269,-0.001216,-0.024969,-0.033251,0.019649,-0.039126,0.033254,0.019344,-0.047013,-0.048944,0.069616,0.049247,0.003528,-0.021370,-0.040338,-0.000985,-0.032081,-0.027301,-0.040681,-0.009709,-0.004885,-0.016007,-0.017827,0.019853,0.016485,-0.025721,0.005944,0.016690,-0.062664,0.030209,-0.025793,-0.002664,-0.017228,0.039807,-0.051178,0.012011,-0.016978,0.062624,0.051334,0.053962,0.024397,0.059106,0.027840,0.007349,0.067335,0.060170,-0.060985,-0.018681,0.043081,-0.005606,-0.028211,-0.049523,0.010107,0.049985,-0.009972,0.019541,-0.001020,-0.039170,-0.016612,0.059463,-0.013873,0.000166,-0.024351,0.001420,-0.060678,-0.034707,-0.036561,-0.067918,-0.048948,-0.053328,0.030630,-0.004044,-0.013010,0.038490,-0.047885,0.064691,-0.053459,-0.035898,0.049965,0.058159,0.021866,-0.062909,0.010273,-0.002050,-0.041334,0.058743,0.037859,-0.009135,0.067586,-0.048136,-0.032699};
  parameter real W2161[0:249] = {-0.023979,-0.040554,0.033268,0.019274,-0.058101,0.016236,0.058962,-0.027802,0.036229,-0.051942,-0.043688,0.017733,-0.030486,-0.036795,-0.031072,0.006291,0.049923,-0.042455,-0.051812,-0.006869,-0.057942,-0.065775,0.059832,0.029086,0.004736,-0.046511,-0.059475,-0.043152,-0.018924,0.056866,0.011762,-0.027466,0.018395,0.018971,0.010336,-0.046380,0.026917,0.027900,0.026472,-0.021020,0.015930,0.014076,-0.026098,-0.036038,-0.006908,-0.042539,-0.042047,-0.006668,-0.049990,0.007368,-0.019884,0.059323,-0.029910,0.042404,-0.017953,0.011955,0.009885,-0.059667,-0.033025,0.049068,0.020062,0.045020,0.006541,0.018330,-0.011366,-0.002312,-0.029627,0.055429,-0.020506,-0.040579,-0.009742,0.018627,0.034502,-0.049753,0.041193,-0.036327,-0.064190,-0.029003,-0.030610,-0.064720,0.008768,0.034339,-0.044468,0.063076,0.007810,-0.014667,-0.035120,-0.028502,-0.032463,0.049735,0.062054,0.059370,-0.038142,0.045828,-0.028988,-0.025328,-0.043992,-0.060865,-0.028036,0.007476,-0.018401,0.050832,0.035798,-0.053713,-0.056534,0.009461,0.051687,-0.044314,0.053108,-0.053123,-0.025958,0.032385,0.057470,-0.008897,0.001359,-0.046235,-0.039361,0.039410,0.042517,-0.029944,-0.019035,0.031579,-0.042601,0.042730,0.028165,-0.044987,0.050658,0.045408,-0.037463,-0.062001,-0.040947,-0.043144,-0.027048,0.053144,-0.049510,0.045745,-0.022187,-0.002050,0.065677,0.016404,-0.039507,0.018294,-0.031564,-0.024698,0.024320,-0.037211,0.049880,-0.027166,-0.002091,-0.031039,0.010147,-0.061009,-0.058544,0.023142,-0.003935,0.008127,0.019485,-0.053985,0.059534,0.047832,0.003602,-0.023698,-0.017060,-0.062842,0.022313,-0.044454,0.003182,0.065998,0.026445,0.048878,-0.040952,0.000772,-0.060245,-0.044582,-0.010408,-0.039601,0.027779,-0.051949,-0.060473,0.058363,0.044767,0.000176,0.022104,-0.007579,0.024121,0.042116,0.022012,-0.031660,-0.059692,-0.037157,0.059454,-0.044552,0.006371,0.063358,-0.037867,-0.010320,0.023652,-0.006395,0.000378,0.041824,0.002354,0.048947,-0.007416,-0.024109,-0.032844,0.059631,0.059093,0.031662,-0.049175,0.010140,-0.005056,0.024875,0.028463,-0.045145,0.034768,-0.052583,0.042501,-0.013569,0.057942,0.021746,-0.048377,0.052517,0.032947,0.054205,-0.058626,-0.047833,0.025253,-0.016386,0.013016,-0.042185,0.028239,-0.049149,-0.007147,0.023855,0.046635,-0.037382,0.020952,-0.007961,-0.032174,0.043167,-0.054853,0.015393,0.013480,0.001707,-0.027838,0.003113,-0.015768,0.016862,0.024524,-0.009860};
  parameter real W2162[0:249] = {0.023845,-0.032150,-0.027803,-0.053124,-0.048050,-0.017484,0.046918,0.053500,-0.046084,-0.030441,0.013065,-0.014706,0.006189,0.014444,-0.022318,-0.022503,-0.019326,-0.023459,-0.015616,0.041200,-0.005822,0.014378,0.006507,0.040011,-0.034493,-0.000440,-0.030930,0.036620,-0.027468,-0.033296,0.056043,-0.064167,0.020610,0.061459,0.037802,0.036213,0.029905,-0.032662,-0.058391,0.021107,-0.036393,0.051640,0.026106,-0.038148,-0.021704,-0.060900,-0.047653,-0.061429,-0.015857,-0.041339,-0.060696,-0.001593,0.016239,-0.035618,0.024840,0.005972,0.005732,-0.020030,-0.045547,-0.049493,0.022071,-0.037243,-0.051569,0.007530,-0.032820,0.027503,0.042265,-0.042561,-0.038636,-0.012021,0.015701,-0.004431,0.052893,-0.026877,0.001586,0.011777,-0.038655,0.062583,-0.029601,-0.045817,0.026141,0.028197,-0.036154,0.051026,0.018018,-0.053985,0.045772,-0.015216,-0.030414,-0.005633,-0.055029,-0.003664,-0.040895,-0.029523,-0.008128,-0.054855,-0.027998,0.052328,0.011937,-0.028333,0.020929,-0.004392,0.043340,0.004759,0.047950,-0.030251,-0.044322,-0.045313,-0.016002,0.027054,0.058195,-0.003128,0.030742,-0.051359,0.062470,0.041450,0.050929,-0.009090,-0.001833,-0.016975,0.035036,-0.052480,-0.050215,0.048146,0.013912,-0.045535,0.030964,0.024578,-0.036712,-0.001774,0.013088,-0.061473,-0.055955,0.044291,0.008402,0.041652,0.042259,0.019064,-0.003455,0.052359,0.026827,-0.011714,0.054723,0.008726,-0.047383,0.053703,-0.013448,0.041734,0.038346,0.058023,-0.035903,-0.018094,0.039327,-0.043739,-0.023738,-0.030095,0.010725,-0.024169,0.046517,0.031253,-0.007524,0.055611,-0.002276,-0.050324,0.062191,-0.002650,-0.012566,0.027345,0.017100,0.018887,-0.060072,-0.026701,0.038903,0.022409,0.048855,-0.050794,-0.037619,-0.005961,0.023883,0.056033,0.054964,0.052525,0.013663,0.035198,0.047274,0.061382,0.060171,-0.016298,-0.007325,0.019522,-0.037084,-0.013201,0.004217,-0.038379,0.002695,0.051554,-0.062181,-0.044090,0.058460,-0.024861,0.034692,0.019266,0.017156,-0.023254,-0.025956,-0.029415,0.024194,-0.041013,-0.049176,-0.040378,0.033175,0.055599,-0.039714,-0.028007,-0.012091,0.012675,-0.041057,0.062230,0.024137,-0.005892,0.001499,0.048364,-0.001657,-0.001150,0.040285,-0.054017,0.061635,0.030342,0.017308,0.059564,-0.046014,0.039270,-0.041023,-0.028921,-0.050049,0.057310,0.044441,-0.053605,0.037807,-0.039047,0.041979,-0.005181,-0.055115,-0.022201,0.050951,0.055094,-0.055404,-0.011866,-0.024922,-0.012619};
  parameter real W2163[0:249] = {0.054328,-0.057774,-0.036759,0.048579,0.025114,-0.026844,-0.040855,-0.044009,-0.009641,-0.053295,-0.007016,0.026496,-0.042964,0.055171,-0.000246,-0.020927,-0.026690,-0.018490,0.028920,0.046830,0.049456,-0.028826,0.028423,0.007241,0.039165,-0.044084,0.023210,0.034240,-0.025815,-0.006481,0.061852,0.048357,-0.027903,0.041628,-0.006941,-0.002694,0.058933,0.033171,-0.059390,0.053899,-0.016764,-0.058772,-0.012580,0.019150,-0.031066,-0.015426,0.016337,0.031824,-0.040411,0.026820,0.005008,0.054704,-0.008140,0.024585,0.044560,0.030447,0.003379,-0.002486,0.014948,0.011403,0.050786,0.051177,0.066472,0.027286,0.036693,0.006708,-0.052589,-0.016820,-0.013572,-0.001119,-0.050406,-0.014122,-0.038422,0.003598,0.043871,0.053904,0.042550,0.056973,-0.000192,-0.044810,-0.039424,-0.015305,-0.029658,0.007379,-0.014189,0.046440,-0.061586,0.013093,0.013215,-0.034275,-0.035675,-0.047304,-0.053277,0.015300,-0.062424,-0.023803,-0.026427,-0.055005,0.038636,-0.061874,-0.033051,0.029504,-0.038423,0.059954,-0.059408,-0.043119,0.061125,0.017936,-0.039354,-0.004111,-0.009760,0.050597,-0.037009,0.004367,-0.048452,-0.001076,0.001753,-0.027299,0.043013,-0.015491,0.041548,-0.050040,-0.011746,-0.038501,-0.016979,-0.036303,-0.025053,0.005676,0.037038,-0.005625,0.025008,-0.053319,-0.036404,-0.045224,0.033721,-0.007174,0.034690,0.016541,-0.018762,0.007532,-0.018910,0.029318,-0.008223,0.009050,0.042766,0.017672,0.028828,0.041616,0.002871,0.005306,-0.044987,0.052022,-0.004629,-0.049689,-0.049171,-0.035343,0.031573,0.017024,0.050580,-0.044377,-0.059953,0.059694,0.037143,-0.015217,0.012475,0.062126,-0.049642,0.013887,0.023525,0.042234,-0.042006,0.046066,0.062928,0.047415,-0.013808,0.061190,-0.035466,-0.042016,-0.034131,-0.049476,-0.051086,-0.015162,0.055850,-0.020716,0.049148,0.003481,-0.003531,0.035311,-0.003636,-0.035908,0.006693,-0.050509,-0.025443,-0.018406,-0.015332,-0.048621,-0.037433,0.003776,-0.056252,-0.001058,0.022548,0.009563,-0.062778,-0.009291,0.041782,-0.035262,0.045794,-0.029382,0.002922,-0.023600,-0.001608,0.040325,0.054187,-0.002942,-0.045567,0.053159,-0.004072,-0.020746,-0.021127,0.020662,0.023898,0.012184,-0.056388,-0.035971,0.013011,0.020376,-0.010407,-0.007809,-0.061491,-0.053229,-0.023075,-0.021926,0.033791,-0.035674,-0.020376,-0.062622,-0.029981,0.040296,-0.053355,0.004418,-0.049223,-0.026370,0.024700,0.002368,-0.019959,0.016929,0.003992,-0.064894,0.046841,0.055813};
  parameter real W2164[0:249] = {-0.020853,0.007170,0.033213,-0.039711,-0.010323,0.040138,-0.012053,0.056889,-0.050170,-0.007585,0.031035,0.025066,0.001303,-0.027269,-0.007249,0.059093,-0.022461,-0.029646,0.054128,-0.049138,-0.056573,-0.049804,0.014164,0.037191,-0.049760,0.026991,0.043888,0.016168,-0.058736,0.007150,0.049929,0.020520,0.029304,0.034668,-0.016442,-0.000987,0.006296,-0.025372,0.019156,0.012748,-0.048941,-0.028141,-0.037320,-0.055464,-0.045244,0.018998,0.021845,0.032013,-0.024223,-0.026346,-0.008030,-0.031787,0.030870,0.046872,0.049486,-0.032743,-0.021384,-0.034910,-0.025731,-0.036346,-0.058197,-0.063027,0.019216,0.026018,0.026370,-0.043920,0.012715,-0.041508,-0.073086,0.042793,-0.029261,0.048129,0.005554,-0.065085,0.038263,0.040252,0.058801,-0.048812,0.036233,0.014417,-0.044142,-0.012228,-0.064947,0.050674,-0.017410,0.014968,-0.047275,0.027822,0.010561,-0.030173,-0.008900,-0.018288,-0.047722,0.067513,0.039912,0.043568,-0.004521,-0.004242,-0.019304,0.049040,-0.048971,-0.004558,0.052857,-0.061874,-0.018023,-0.062242,-0.038212,0.018836,0.059945,-0.039033,0.007913,-0.036831,-0.007132,-0.037599,0.049503,-0.006800,-0.064139,0.019538,0.060485,-0.056477,-0.043113,0.043778,0.046514,0.025017,-0.036540,0.005965,0.008671,0.013628,-0.033050,-0.015879,0.016458,0.006391,-0.008578,-0.041703,0.065085,0.007522,0.029864,-0.032146,0.011223,-0.001369,-0.005073,0.049632,-0.016931,-0.058812,0.055137,-0.028650,0.002584,-0.046725,0.021172,-0.016674,-0.035653,0.053069,-0.036002,0.009549,-0.048490,0.038750,0.033151,0.022690,0.041657,0.010709,-0.014888,-0.058255,0.063453,0.009942,-0.062047,-0.010230,-0.051895,0.047037,0.058372,0.043965,0.055761,-0.004898,0.029170,-0.063858,-0.009470,0.013666,-0.062579,-0.017221,-0.013329,0.003513,0.037296,0.061157,0.058260,0.057903,0.045870,-0.043653,0.047612,0.050536,-0.000801,0.055076,-0.041718,0.036611,-0.020918,0.033698,0.006701,-0.002878,-0.025300,-0.015390,-0.008340,0.037644,-0.002797,-0.027523,0.008920,0.007399,-0.023019,-0.058634,-0.016386,0.053218,-0.062317,0.038702,-0.009665,-0.037375,-0.057690,-0.003381,0.061105,0.010353,0.010502,0.021974,0.040339,0.014784,0.007606,0.002312,-0.018293,-0.048617,0.022965,-0.018546,0.061822,0.059817,-0.053860,0.014557,0.034271,0.056205,0.054331,0.006005,-0.006989,-0.025470,-0.031188,-0.051181,0.022257,-0.053114,0.029368,0.002810,-0.014348,-0.008198,-0.047277,-0.017746,-0.040931,0.053929,0.010372,-0.003803};
  parameter real W2165[0:249] = {0.011317,-0.055813,-0.019924,-0.062282,-0.035409,0.008980,-0.000106,0.008585,0.028816,-0.051092,-0.047253,-0.028811,0.001548,0.008212,-0.062601,0.022865,-0.013632,-0.015334,-0.048723,-0.055998,0.007780,0.028442,0.021232,0.013111,0.037120,0.030461,-0.039973,-0.045097,-0.033734,0.027981,-0.029441,0.040152,-0.043516,-0.051107,-0.041281,0.058485,0.006727,-0.036503,0.012674,-0.025215,0.006368,-0.049649,-0.014556,0.019406,0.056094,0.043856,0.019900,-0.044053,-0.019802,-0.020939,0.012065,0.055995,0.016471,0.037929,0.008767,-0.039935,-0.021838,-0.001566,0.015842,0.007032,0.005163,-0.032712,-0.037113,-0.051762,0.035871,0.050219,-0.021443,0.035006,-0.023154,0.013720,-0.004035,-0.008604,-0.020014,-0.060973,0.073073,0.019019,0.014239,-0.029308,0.048366,-0.019787,0.059225,0.016517,0.030363,-0.021174,-0.015996,-0.061009,0.011310,0.045803,-0.016830,-0.002154,-0.042251,0.035725,0.019800,-0.047378,0.055388,-0.055715,-0.048289,0.062632,-0.015541,0.050466,0.010356,-0.042133,-0.063518,-0.042378,-0.032935,0.030084,-0.023094,0.007686,-0.006487,-0.037026,-0.007272,0.052504,-0.041203,0.007826,0.011485,0.046493,0.019467,0.032351,-0.015007,-0.003816,-0.022242,-0.021497,-0.065994,0.056074,-0.066373,0.001223,-0.013747,0.014385,0.009001,0.040584,0.017987,-0.023249,0.007451,-0.030237,-0.051112,0.048588,-0.046645,0.034610,-0.057958,-0.050026,-0.020098,-0.041721,0.002940,-0.040019,-0.035938,-0.013082,-0.012757,-0.025333,0.050758,-0.052774,0.016820,0.008030,-0.017953,-0.008722,-0.058201,-0.054993,0.037012,0.002034,0.020425,-0.046505,0.035603,0.045551,0.027030,0.029613,0.003614,0.056375,0.036074,0.043243,-0.002985,-0.040483,-0.011007,0.041597,0.015522,0.043265,0.035051,-0.003531,-0.025395,0.019164,-0.039776,0.036105,-0.021899,0.027968,0.050400,-0.034798,-0.002385,0.001549,0.026501,0.038614,-0.050003,-0.019301,0.029413,0.033241,0.046068,-0.027732,0.011333,-0.035529,0.025800,-0.059678,0.038778,-0.008913,-0.043376,-0.025919,0.030406,-0.049588,-0.056955,-0.049157,-0.024344,0.000942,0.033257,-0.043416,0.019049,0.033404,0.011983,0.038131,-0.007534,0.038999,0.022960,-0.061037,-0.011013,-0.018172,0.017697,-0.009137,0.037654,0.036582,-0.036738,0.047585,-0.034965,-0.056307,0.062502,-0.027954,0.005931,0.032684,0.059201,-0.020047,0.013024,-0.058639,0.052467,-0.051710,0.058910,0.003537,0.036652,0.053982,0.031022,-0.049344,0.022375,0.050533,-0.018102,-0.027682,-0.009645,0.044142};
